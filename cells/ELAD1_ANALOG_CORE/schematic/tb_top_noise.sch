** sch_path: cells/ELAD1_ANALOG_CORE/schematic/tb_top_noise.sch
**.subckt tb_top_noise
XCORE UA0 UA1 UA2 UA3 UA4 UA5 EN_MG EN_MC EN_PG EN_PC EN_N CLR_MG CLR_MC CLR_PG CLR_PC CLR_N HEN
+ AGG_CLK VDPWR VGND ELAD1_ANALOG_CORE
CPI5 UA5 0 2.5p m=1
RPA5 P5 UA5 500 m=1
CPE5 P5 0 2.5p m=1
VP5 P5 0 0
CPI4 UA4 0 2.5p m=1
RPA4 P4 UA4 500 m=1
CPE4 P4 0 2.5p m=1
RL4 P4 0 1e9 m=1
CL4 P4 0 5p m=1
CPI3 UA3 0 2.5p m=1
RPA3 P3 UA3 500 m=1
CPE3 P3 0 2.5p m=1
RL3 P3 0 1e9 m=1
CL3 P3 0 5p m=1
CPI2 UA2 0 2.5p m=1
RPA2 P2 UA2 500 m=1
CPE2 P2 0 2.5p m=1
RM2 P2 0 1e9 m=1
CPI1 UA1 0 2.5p m=1
RPA1 P1 UA1 500 m=1
CPE1 P1 0 2.5p m=1
VQ P1 0 0.7712
CPI0 UA0 0 2.5p m=1
RPA0 P0 UA0 500 m=1
CPE0 P0 0 2.5p m=1
VP0 P0 0 0
VGNDS VGND 0 0
VEMG EN_MG 0 0
VEMC EN_MC 0 0
VEPG EN_PG 0 0
VEPC EN_PC 0 0
VEN EN_N 0 1.8
VCMG CLR_MG 0 1.8
VCMC CLR_MC 0 1.8
VCPG CLR_PG 0 1.8
VCPC CLR_PC 0 1.8
VCN CLR_N 0 0
VHEN HEN 0 0
VAGG AGG_CLK 0 PULSE(0 1.8 10u 2n 2n 24.998u 50u)
RPDN vsup VDPWR 5 m=1
VSUP vsup 0 1.8
**** begin user architecture code

.option reltol=1e-4 abstol=1e-13 vntol=1e-7 gmin=1e-15 method=gear
.save v(P1) v(P2) v(P3) v(P4) v(VDPWR) v(AGG_CLK) v(xcore.subi) i(vsup)
.tran 20n 110u
.control
run
meas tran v3dc avg v(P3) from=5u to=9.5u
meas tran v4dc avg v(P4) from=5u to=9.5u
meas tran sh avg v(xcore.subi) from=80u to=84.9u
meas tran sl avg v(xcore.subi) from=105u to=109.9u
meas tran p2h avg v(P2) from=80u to=84.9u
meas tran p2l avg v(P2) from=105u to=109.9u
meas tran p3h avg v(P3) from=80u to=84.9u
meas tran p3l avg v(P3) from=105u to=109.9u
meas tran p4h avg v(P4) from=80u to=84.9u
meas tran p4l avg v(P4) from=105u to=109.9u
meas tran vdd_pp pp v(VDPWR) from=60u to=110u
let subi_step = sh-sl
let sense_err = abs((p2h-p2l)-(sh-sl))
let p3_step = abs(p3h-p3l)
let p4_step = abs(p4h-p4l)
echo ROW noise div=2 v3dc=$&v3dc v4dc=$&v4dc subi_step=$&subi_step sense_err=$&sense_err
+ p3_step=$&p3_step p4_step=$&p4_step vdd_pp=$&vdd_pp
.endc

.lib $::SKYWATER_MODELS/sky130.lib.spice tt
**** end user architecture code
**.ends

* expanding   symbol:  ELAD1_ANALOG_CORE.sym # of pins=20
** sym_path: cells/ELAD1_ANALOG_CORE/schematic/ELAD1_ANALOG_CORE.sym
** sch_path: cells/ELAD1_ANALOG_CORE/schematic/ELAD1_ANALOG_CORE.sch
.subckt ELAD1_ANALOG_CORE UA0 UA1 UA2 UA3 UA4 UA5 EN_MG EN_MC EN_PG EN_PC EN_N CLR_MG CLR_MC CLR_PG
+ CLR_PC CLR_N HEN AGG_CLK VDPWR VGND
*.iopin UA0
*.iopin UA1
*.iopin UA2
*.iopin UA3
*.iopin UA4
*.iopin UA5
*.iopin EN_MG
*.iopin EN_MC
*.iopin EN_PG
*.iopin EN_PC
*.iopin EN_N
*.iopin CLR_MG
*.iopin CLR_MC
*.iopin CLR_PG
*.iopin CLR_PC
*.iopin CLR_N
*.iopin HEN
*.iopin AGG_CLK
*.iopin VDPWR
*.iopin VGND
XSEL UA0 UA1 UA2 UA3 UA4 REF_G OUT_G REF_C OUT_C VBIAS_G VINP_G VINM_G D1_G D2_G VBIAS_C VINP_C
+ VINM_C D1_C D2_C VQUIET_A VQUIET_B OUT_A OUT_B SUBI EN_MG EN_MC EN_PG EN_PC EN_N CLR_MG CLR_MC CLR_PG
+ CLR_PC CLR_N VDPWR VGND ELAD1_ANALOG_SELECTOR
XMIR_G REF_G OUT_G VGND ELAD1_MIRROR_GROUPED
XMIR_C REF_C OUT_C VGND ELAD1_MIRROR_CC
XPAIR_G VINP_G VINM_G D1_G D2_G VBIAS_G VGND ELAD1_PAIR_GROUPED
XPAIR_C VINP_C VINM_C D1_C D2_C VBIAS_C VGND ELAD1_PAIR_CC
XVIC_A VQUIET_A OUT_A VDPWR VGND VGND ELAD1_VICTIM_BASELINE
XVIC_B VQUIET_B OUT_B VDPWR VGND VGND ELAD1_VICTIM_GUARDED
XHTR UA5 HEN VGND ELAD1_HEATER
XAGG AGG_CLK EN_N VDPWR VGND SUBI ELAD1_AGGRESSOR
.ends


* expanding   symbol:  ELAD1_ANALOG_SELECTOR.sym # of pins=36
** sym_path: cells/ELAD1_ANALOG_SELECTOR/schematic/ELAD1_ANALOG_SELECTOR.sym
** sch_path: cells/ELAD1_ANALOG_SELECTOR/schematic/ELAD1_ANALOG_SELECTOR.sch
.subckt ELAD1_ANALOG_SELECTOR UA0 UA1 UA2 UA3 UA4 REF_G OUT_G REF_C OUT_C VBIAS_G VINP_G VINM_G D1_G
+ D2_G VBIAS_C VINP_C VINM_C D1_C D2_C VQUIET_A VQUIET_B OUT_A OUT_B SUBI EN_MG EN_MC EN_PG EN_PC EN_N
+ CLR_MG CLR_MC CLR_PG CLR_PC CLR_N VDPWR VGND
*.iopin UA0
*.iopin UA1
*.iopin UA2
*.iopin UA3
*.iopin UA4
*.iopin REF_G
*.iopin OUT_G
*.iopin REF_C
*.iopin OUT_C
*.iopin VBIAS_G
*.iopin VINP_G
*.iopin VINM_G
*.iopin D1_G
*.iopin D2_G
*.iopin VBIAS_C
*.iopin VINP_C
*.iopin VINM_C
*.iopin D1_C
*.iopin D2_C
*.iopin VQUIET_A
*.iopin VQUIET_B
*.iopin OUT_A
*.iopin OUT_B
*.iopin SUBI
*.iopin EN_MG
*.iopin EN_MC
*.iopin EN_PG
*.iopin EN_PC
*.iopin EN_N
*.iopin CLR_MG
*.iopin CLR_MC
*.iopin CLR_PG
*.iopin CLR_PC
*.iopin CLR_N
*.iopin VDPWR
*.iopin VGND
XSMG0 UA0 REF_G EN_MG ENB_MG VDPWR VGND ELAD1_TGA
XSMG3 UA3 REF_G EN_MG ENB_MG VDPWR VGND ELAD1_TGB
XSMG2 UA2 OUT_G EN_MG ENB_MG VDPWR VGND ELAD1_TGB
XSMG4 UA4 OUT_G EN_MG ENB_MG VDPWR VGND ELAD1_TGA
XCL_REF_G REF_G CLR_MG VGND ELAD1_CLAMP
XSMC0 UA0 REF_C EN_MC ENB_MC VDPWR VGND ELAD1_TGA
XSMC3 UA3 REF_C EN_MC ENB_MC VDPWR VGND ELAD1_TGB
XSMC2 UA2 OUT_C EN_MC ENB_MC VDPWR VGND ELAD1_TGB
XSMC4 UA4 OUT_C EN_MC ENB_MC VDPWR VGND ELAD1_TGA
XCL_REF_C REF_C CLR_MC VGND ELAD1_CLAMP
XSPG0 UA0 VBIAS_G EN_PG ENB_PG VDPWR VGND ELAD1_TGA
XSPG1 UA1 VINP_G EN_PG ENB_PG VDPWR VGND ELAD1_TGB
XSPG2 UA2 VINM_G EN_PG ENB_PG VDPWR VGND ELAD1_TGB
XSPG3 UA3 D1_G EN_PG ENB_PG VDPWR VGND ELAD1_TGA
XSPG4 UA4 D2_G EN_PG ENB_PG VDPWR VGND ELAD1_TGA
XCL_VBIAS_G VBIAS_G CLR_PG VGND ELAD1_CLAMP
XCL_VINP_G VINP_G CLR_PG VGND ELAD1_CLAMP
XCL_VINM_G VINM_G CLR_PG VGND ELAD1_CLAMP
XSPC0 UA0 VBIAS_C EN_PC ENB_PC VDPWR VGND ELAD1_TGA
XSPC1 UA1 VINP_C EN_PC ENB_PC VDPWR VGND ELAD1_TGB
XSPC2 UA2 VINM_C EN_PC ENB_PC VDPWR VGND ELAD1_TGB
XSPC3 UA3 D1_C EN_PC ENB_PC VDPWR VGND ELAD1_TGA
XSPC4 UA4 D2_C EN_PC ENB_PC VDPWR VGND ELAD1_TGA
XCL_VBIAS_C VBIAS_C CLR_PC VGND ELAD1_CLAMP
XCL_VINP_C VINP_C CLR_PC VGND ELAD1_CLAMP
XCL_VINM_C VINM_C CLR_PC VGND ELAD1_CLAMP
XSN0 UA0 SUBI EN_N ENB_N VDPWR VGND ELAD1_TGB
XSN2 UA2 SUBI EN_N ENB_N VDPWR VGND ELAD1_TGB
XSN1A UA1 VQUIET_A EN_N ENB_N VDPWR VGND ELAD1_TGB
XSN3 UA3 OUT_A EN_N ENB_N VDPWR VGND ELAD1_TSW
XSN1B UA1 VQUIET_B EN_N ENB_N VDPWR VGND ELAD1_TGB
XSN4 UA4 OUT_B EN_N ENB_N VDPWR VGND ELAD1_TSW
XCL_VQ_A VQUIET_A CLR_N VGND ELAD1_CLAMP
XCL_VQ_B VQUIET_B CLR_N VGND ELAD1_CLAMP
XINV_MG EN_MG ENB_MG VDPWR VGND ELAD1_INV
XINV_MC EN_MC ENB_MC VDPWR VGND ELAD1_INV
XINV_PG EN_PG ENB_PG VDPWR VGND ELAD1_INV
XINV_PC EN_PC ENB_PC VDPWR VGND ELAD1_INV
XINV_N EN_N ENB_N VDPWR VGND ELAD1_INV
.ends


* expanding   symbol:  ELAD1_MIRROR_GROUPED.sym # of pins=3
** sym_path: cells/ELAD1_MIRROR_GROUPED/schematic/ELAD1_MIRROR_GROUPED.sym
** sch_path: cells/ELAD1_MIRROR_GROUPED/schematic/ELAD1_MIRROR_GROUPED.sch
.subckt ELAD1_MIRROR_GROUPED REF OUT VGND
*.iopin REF
*.iopin OUT
*.iopin VGND
XM1 REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=8 nf=1 ad='int((1 + 1)/2) * 8 / 1 * 0.29' as='int((1 + 2)/2) * 8 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (8 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (8 / 1 + 0.29)' nrd='0.29 / 8 ' nrs='0.29 / 8 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=8 nf=1 ad='int((1 + 1)/2) * 8 / 1 * 0.29' as='int((1 + 2)/2) * 8 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (8 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (8 / 1 + 0.29)' nrd='0.29 / 8 ' nrs='0.29 / 8 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=8 nf=1 ad='int((1 + 1)/2) * 8 / 1 * 0.29' as='int((1 + 2)/2) * 8 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (8 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (8 / 1 + 0.29)' nrd='0.29 / 8 ' nrs='0.29 / 8 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_MIRROR_CC.sym # of pins=3
** sym_path: cells/ELAD1_MIRROR_CC/schematic/ELAD1_MIRROR_CC.sym
** sch_path: cells/ELAD1_MIRROR_CC/schematic/ELAD1_MIRROR_CC.sch
.subckt ELAD1_MIRROR_CC REF OUT VGND
*.iopin REF
*.iopin OUT
*.iopin VGND
XA[3] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[2] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[1] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[0] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[3] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[2] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[1] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[0] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[15] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[14] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[13] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[12] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[11] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[10] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[9] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[8] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[7] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[6] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[5] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[4] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[3] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[2] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[1] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[0] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_PAIR_GROUPED.sym # of pins=6
** sym_path: cells/ELAD1_PAIR_GROUPED/schematic/ELAD1_PAIR_GROUPED.sym
** sch_path: cells/ELAD1_PAIR_GROUPED/schematic/ELAD1_PAIR_GROUPED.sch
.subckt ELAD1_PAIR_GROUPED VINP VINM D1 D2 VBIAS VGND
*.iopin VINP
*.iopin VINM
*.iopin D1
*.iopin D2
*.iopin VBIAS
*.iopin VGND
XA0 D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA1 D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA2 D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA3 D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB0 D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB1 D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB2 D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB3 D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT0 TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT1 TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT2 TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT3 TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR0 VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR1 VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR2 VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR3 VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM0 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM1 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM2 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM3 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM4 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM5 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM6 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM7 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM8 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM9 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM10 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM11 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM12 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM13 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM14 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM15 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM16 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM17 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM18 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM19 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM20 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM21 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM22 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM23 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM24 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM25 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM26 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM27 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM28 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM29 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM30 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM31 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_PAIR_CC.sym # of pins=6
** sym_path: cells/ELAD1_PAIR_CC/schematic/ELAD1_PAIR_CC.sym
** sch_path: cells/ELAD1_PAIR_CC/schematic/ELAD1_PAIR_CC.sch
.subckt ELAD1_PAIR_CC VINP VINM D1 D2 VBIAS VGND
*.iopin D1
*.iopin D2
*.iopin VINP
*.iopin VINM
*.iopin VBIAS
*.iopin VGND
XA[3] D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[2] D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[1] D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[0] D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[3] D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[2] D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[1] D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[0] D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT[3] TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT[2] TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT[1] TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT[0] TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR[3] VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR[2] VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR[1] VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR[0] VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[31] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[30] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[29] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[28] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[27] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[26] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[25] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[24] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[23] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[22] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[21] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[20] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[19] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[18] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[17] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[16] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[15] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[14] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[13] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[12] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[11] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[10] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[9] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[8] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[7] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[6] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[5] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[4] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[3] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[2] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[1] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[0] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_VICTIM_BASELINE.sym # of pins=5
** sym_path: cells/ELAD1_VICTIM_BASELINE/schematic/ELAD1_VICTIM_BASELINE.sym
** sch_path: cells/ELAD1_VICTIM_BASELINE/schematic/ELAD1_VICTIM_BASELINE.sch
.subckt ELAD1_VICTIM_BASELINE VQUIET OUT VDPWR VGND SUBQ
*.iopin VQUIET
*.iopin OUT
*.iopin VDPWR
*.iopin VGND
*.iopin SUBQ
XMVIC[1] OUT VQUIET VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XMVIC[0] OUT VQUIET VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XMD[1] VGND VGND VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=2 m=2
XMD[0] VGND VGND VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=2 m=2
XR1 OUT VDPWR SUBQ sky130_fd_pr__res_xhigh_po_0p69 L=31.7 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_VICTIM_GUARDED.sym # of pins=5
** sym_path: cells/ELAD1_VICTIM_GUARDED/schematic/ELAD1_VICTIM_GUARDED.sym
** sch_path: cells/ELAD1_VICTIM_GUARDED/schematic/ELAD1_VICTIM_GUARDED.sch
.subckt ELAD1_VICTIM_GUARDED VQUIET OUT VDPWR VGND SUBQ
*.iopin VQUIET
*.iopin OUT
*.iopin VDPWR
*.iopin VGND
*.iopin SUBQ
XRLD VDPWR OUT SUBQ sky130_fd_pr__res_xhigh_po W=0.69 L=31.7 mult=1 m=1
XMVIC OUT VQUIET VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[1] VGND VGND VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[0] VGND VGND VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_HEATER.sym # of pins=3
** sym_path: cells/ELAD1_HEATER/schematic/ELAD1_HEATER.sym
** sch_path: cells/ELAD1_HEATER/schematic/ELAD1_HEATER.sch
.subckt ELAD1_HEATER HIN HEN VGND
*.iopin HIN
*.iopin HEN
*.iopin VGND
XRH0 HIN HD VGND sky130_fd_pr__res_high_po W=5.73 L=52.9 mult=1 m=1
XRH1 HIN HD VGND sky130_fd_pr__res_high_po W=5.73 L=52.9 mult=1 m=1
XMSW HD HEN VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=40 nf=1 ad='int((1 + 1)/2) * 40 / 1 * 0.29' as='int((1 + 2)/2) * 40 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (40 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (40 / 1 + 0.29)' nrd='0.29 / 40 ' nrs='0.29 / 40 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_AGGRESSOR.sym # of pins=5
** sym_path: cells/ELAD1_AGGRESSOR/schematic/ELAD1_AGGRESSOR.sym
** sch_path: cells/ELAD1_AGGRESSOR/schematic/ELAD1_AGGRESSOR.sch
.subckt ELAD1_AGGRESSOR AGG_CLK EN VDPWR VGND SUBI
*.iopin AGG_CLK
*.iopin EN
*.iopin VDPWR
*.iopin VGND
*.iopin SUBI
XIC AGG_CLK CKB VDPWR VGND ELAD1_INV
XIE EN ENB VDPWR VGND ELAD1_INV
XGIP1 gip ENB VDPWR VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XGIP2 GI CKB gip VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XGIN1 GI ENB VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
XGIN2 GI CKB VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
XGDP1 gdp ENB VDPWR VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XGDP2 GD AGG_CLK gdp VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XGDN1 GD ENB VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
XGDN2 GD AGG_CLK VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
XRL X VDPWR VGND sky130_fd_pr__res_xhigh_po W=0.69 L=7.3 mult=1 m=1
XMINJ X GI SUBI VGND sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMDUM X GD D VGND sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XRDUM VGND D sky130_fd_pr__res_generic_po W=1 L=15 m=1
.ends


* expanding   symbol:  ELAD1_TGA.sym # of pins=6
** sym_path: cells/ELAD1_TGA/schematic/ELAD1_TGA.sym
** sch_path: cells/ELAD1_TGA/schematic/ELAD1_TGA.sch
.subckt ELAD1_TGA A B EN ENB VDPWR VGND
*.iopin A
*.iopin B
*.iopin EN
*.iopin ENB
*.iopin VDPWR
*.iopin VGND
XMN A EN B VGND sky130_fd_pr__nfet_01v8_lvt L=0.15 W=4 nf=1 ad='int((1 + 1)/2) * 4 / 1 * 0.29' as='int((1 + 2)/2) * 4 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (4 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (4 / 1 + 0.29)' nrd='0.29 / 4 ' nrs='0.29 / 4 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMP A ENB B VDPWR sky130_fd_pr__pfet_01v8_lvt L=0.35 W=12 nf=1 ad='int((1 + 1)/2) * 12 / 1 * 0.29' as='int((1 + 2)/2) * 12 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (12 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (12 / 1 + 0.29)' nrd='0.29 / 12 ' nrs='0.29 / 12 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_TGB.sym # of pins=6
** sym_path: cells/ELAD1_TGB/schematic/ELAD1_TGB.sym
** sch_path: cells/ELAD1_TGB/schematic/ELAD1_TGB.sch
.subckt ELAD1_TGB A B EN ENB VDPWR VGND
*.iopin A
*.iopin B
*.iopin EN
*.iopin ENB
*.iopin VDPWR
*.iopin VGND
XMN A EN B VGND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMP A ENB B VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_CLAMP.sym # of pins=3
** sym_path: cells/ELAD1_CLAMP/schematic/ELAD1_CLAMP.sym
** sch_path: cells/ELAD1_CLAMP/schematic/ELAD1_CLAMP.sch
.subckt ELAD1_CLAMP NODE CLR VGND
*.iopin NODE
*.iopin CLR
*.iopin VGND
XM NODE CLR VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29' as='int((1 + 2)/2) * 0.42 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)' nrd='0.29 / 0.42 '
+ nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_TSW.sym # of pins=6
** sym_path: cells/ELAD1_TSW/schematic/ELAD1_TSW.sym
** sch_path: cells/ELAD1_TSW/schematic/ELAD1_TSW.sch
.subckt ELAD1_TSW A B EN ENB VDPWR VGND
*.iopin A
*.iopin B
*.iopin EN
*.iopin ENB
*.iopin VDPWR
*.iopin VGND
x1 A M EN ENB VDPWR VGND ELAD1_TGA
x1 M B EN ENB VDPWR VGND ELAD1_TGA
XMN1 M ENB VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_INV.sym # of pins=4
** sym_path: cells/ELAD1_INV/schematic/ELAD1_INV.sym
** sch_path: cells/ELAD1_INV/schematic/ELAD1_INV.sch
.subckt ELAD1_INV A Y VDPWR VGND
*.iopin A
*.iopin Y
*.iopin VDPWR
*.iopin VGND
XMN Y A VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=0.65 nf=1 ad='int((1 + 1)/2) * 0.65 / 1 * 0.29' as='int((1 + 2)/2) * 0.65 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (0.65 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.65 / 1 + 0.29)' nrd='0.29 / 0.65 '
+ nrs='0.29 / 0.65 ' sa=0 sb=0 sd=0 mult=1 m=1
XMP Y A VDPWR VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL VGND
.GLOBAL VDPWR
.end
