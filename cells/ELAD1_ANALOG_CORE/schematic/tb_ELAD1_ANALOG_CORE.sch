** sch_path: cells/ELAD1_ANALOG_CORE/schematic/tb_ELAD1_ANALOG_CORE.sch
**.subckt tb_ELAD1_ANALOG_CORE
XMIR M_UA0 0 M_UA2 M_UA3 M_UA4 0 HI 0 0 0 0 0 HI HI HI HI 0 0 VDPWR 0 ELAD1_ANALOG_CORE
VM4 M_UA4 0 0.63
IM 0 M_UA0 DC 5u
XPAIR P_UA0 P_UA1 P_UA2 P_UA3 P_UA4 0 0 0 HI 0 0 HI HI 0 HI HI 0 0 VDPWR 0 ELAD1_ANALOG_CORE
VP4 P_UA4 0 1.2
VP3 P_UA3 0 1.2
VP2 P_UA2 0 1.0
VP1 P_UA1 0 1.0
IP 0 P_UA0 DC 10u
XNOI 0 N_UA1 0 N_UA3 N_UA4 0 0 0 0 0 HI HI HI HI HI 0 0 0 VDPWR 0 ELAD1_ANALOG_CORE
VN1 N_UA1 0 0.771
XHTR H_UA0 0 0 0 0 H_UA5 0 0 0 0 0 HI HI HI HI HI HI 0 VDPWR 0 ELAD1_ANALOG_CORE
RP H_EXT H_UA5 500 m=1
VEXT H_EXT 0 1.8
VH0 H_UA0 0 0.9
VHI HI 0 1.8
VDD VDPWR 0 1.8
**** begin user architecture code

.control
option rshunt=1e12
let vf = 0.63
let k = 0
while k < 5
alter VM4 dc = $&vf
op
let vf = vf + v(M_UA3) - v(M_UA2)
let k = k + 1
end
alter VM4 dc = $&vf
op
let iout = -i(VM4)
let mirror_err_pct = 100*(iout-5e-6)/5e-6
let mirror_vref = v(M_UA3)
let pair_isum = -(i(VP3)+i(VP4))
let pair_imbalance_pct = 100*(i(VP3)-i(VP4))/(i(VP3)+i(VP4))
let noise_vout_base = v(N_UA3)
let noise_vout_guard = v(N_UA4)
let heater_i = -i(VEXT)
let idle_leak_ua0 = abs(i(VH0))
print mirror_err_pct mirror_vref pair_isum pair_imbalance_pct
print noise_vout_base noise_vout_guard heater_i idle_leak_ua0
write tb_ELAD1_ANALOG_CORE.raw
.endc

.lib $::SKYWATER_MODELS/sky130.lib.spice tt
**** end user architecture code
**.ends

* expanding   symbol:  ELAD1_ANALOG_CORE.sym # of pins=20
** sym_path: cells/ELAD1_ANALOG_CORE/schematic/ELAD1_ANALOG_CORE.sym
** sch_path: cells/ELAD1_ANALOG_CORE/schematic/ELAD1_ANALOG_CORE.sch
.subckt ELAD1_ANALOG_CORE UA0 UA1 UA2 UA3 UA4 UA5 EN_MG EN_MC EN_PG EN_PC EN_N CLR_MG CLR_MC CLR_PG
+ CLR_PC CLR_N HEN AGG_CLK VDPWR VGND
*.iopin UA0
*.iopin UA1
*.iopin UA2
*.iopin UA3
*.iopin UA4
*.iopin UA5
*.iopin EN_MG
*.iopin EN_MC
*.iopin EN_PG
*.iopin EN_PC
*.iopin EN_N
*.iopin CLR_MG
*.iopin CLR_MC
*.iopin CLR_PG
*.iopin CLR_PC
*.iopin CLR_N
*.iopin HEN
*.iopin AGG_CLK
*.iopin VDPWR
*.iopin VGND
XSEL UA0 UA1 UA2 UA3 UA4 REF_G OUT_G REF_C OUT_C VBIAS_G VINP_G VINM_G D1_G D2_G VBIAS_C VINP_C
+ VINM_C D1_C D2_C VQUIET_A VQUIET_B OUT_A OUT_B EN_MG EN_MC EN_PG EN_PC EN_N CLR_MG CLR_MC CLR_PG CLR_PC
+ CLR_N VDPWR VGND ELAD1_ANALOG_SELECTOR
XMIR_G REF_G OUT_G VGND ELAD1_MIRROR_GROUPED
XMIR_C REF_C OUT_C VGND ELAD1_MIRROR_CC
XPAIR_G VINP_G VINM_G D1_G D2_G VBIAS_G VGND ELAD1_PAIR_GROUPED
XPAIR_C VINP_C VINM_C D1_C D2_C VBIAS_C VGND ELAD1_PAIR_CC
XVIC_A VQUIET_A OUT_A VDPWR VGND VGND ELAD1_VICTIM_BASELINE
XVIC_B VQUIET_B OUT_B VDPWR VGND VGND ELAD1_VICTIM_GUARDED
XHTR UA5 HEN VGND ELAD1_HEATER
XAGG AGG_CLK VDPWR VGND ELAD1_AGGRESSOR
.ends


* expanding   symbol:  ELAD1_ANALOG_SELECTOR.sym # of pins=35
** sym_path: cells/ELAD1_ANALOG_SELECTOR/schematic/ELAD1_ANALOG_SELECTOR.sym
** sch_path: cells/ELAD1_ANALOG_SELECTOR/schematic/ELAD1_ANALOG_SELECTOR.sch
.subckt ELAD1_ANALOG_SELECTOR UA0 UA1 UA2 UA3 UA4 REF_G OUT_G REF_C OUT_C VBIAS_G VINP_G VINM_G D1_G
+ D2_G VBIAS_C VINP_C VINM_C D1_C D2_C VQUIET_A VQUIET_B OUT_A OUT_B EN_MG EN_MC EN_PG EN_PC EN_N CLR_MG
+ CLR_MC CLR_PG CLR_PC CLR_N VDPWR VGND
*.iopin UA0
*.iopin UA1
*.iopin UA2
*.iopin UA3
*.iopin UA4
*.iopin REF_G
*.iopin OUT_G
*.iopin REF_C
*.iopin OUT_C
*.iopin VBIAS_G
*.iopin VINP_G
*.iopin VINM_G
*.iopin D1_G
*.iopin D2_G
*.iopin VBIAS_C
*.iopin VINP_C
*.iopin VINM_C
*.iopin D1_C
*.iopin D2_C
*.iopin VQUIET_A
*.iopin VQUIET_B
*.iopin OUT_A
*.iopin OUT_B
*.iopin EN_MG
*.iopin EN_MC
*.iopin EN_PG
*.iopin EN_PC
*.iopin EN_N
*.iopin CLR_MG
*.iopin CLR_MC
*.iopin CLR_PG
*.iopin CLR_PC
*.iopin CLR_N
*.iopin VDPWR
*.iopin VGND
XSMG0 UA0 REF_G EN_MG ENB_MG VDPWR VGND ELAD1_TGA
XSMG3 UA3 REF_G EN_MG ENB_MG VDPWR VGND ELAD1_TGB
XSMG2 UA2 OUT_G EN_MG ENB_MG VDPWR VGND ELAD1_TGB
XSMG4 UA4 OUT_G EN_MG ENB_MG VDPWR VGND ELAD1_TGA
XCL_REF_G REF_G CLR_MG VGND ELAD1_CLAMP
XSMC0 UA0 REF_C EN_MC ENB_MC VDPWR VGND ELAD1_TGA
XSMC3 UA3 REF_C EN_MC ENB_MC VDPWR VGND ELAD1_TGB
XSMC2 UA2 OUT_C EN_MC ENB_MC VDPWR VGND ELAD1_TGB
XSMC4 UA4 OUT_C EN_MC ENB_MC VDPWR VGND ELAD1_TGA
XCL_REF_C REF_C CLR_MC VGND ELAD1_CLAMP
XSPG0 UA0 VBIAS_G EN_PG ENB_PG VDPWR VGND ELAD1_TGA
XSPG1 UA1 VINP_G EN_PG ENB_PG VDPWR VGND ELAD1_TGB
XSPG2 UA2 VINM_G EN_PG ENB_PG VDPWR VGND ELAD1_TGB
XSPG3 UA3 D1_G EN_PG ENB_PG VDPWR VGND ELAD1_TGA
XSPG4 UA4 D2_G EN_PG ENB_PG VDPWR VGND ELAD1_TGA
XCL_VBIAS_G VBIAS_G CLR_PG VGND ELAD1_CLAMP
XCL_VINP_G VINP_G CLR_PG VGND ELAD1_CLAMP
XCL_VINM_G VINM_G CLR_PG VGND ELAD1_CLAMP
XSPC0 UA0 VBIAS_C EN_PC ENB_PC VDPWR VGND ELAD1_TGA
XSPC1 UA1 VINP_C EN_PC ENB_PC VDPWR VGND ELAD1_TGB
XSPC2 UA2 VINM_C EN_PC ENB_PC VDPWR VGND ELAD1_TGB
XSPC3 UA3 D1_C EN_PC ENB_PC VDPWR VGND ELAD1_TGA
XSPC4 UA4 D2_C EN_PC ENB_PC VDPWR VGND ELAD1_TGA
XCL_VBIAS_C VBIAS_C CLR_PC VGND ELAD1_CLAMP
XCL_VINP_C VINP_C CLR_PC VGND ELAD1_CLAMP
XCL_VINM_C VINM_C CLR_PC VGND ELAD1_CLAMP
XSN1A UA1 VQUIET_A EN_N ENB_N VDPWR VGND ELAD1_TGB
XSN3 UA3 OUT_A EN_N ENB_N VDPWR VGND ELAD1_TSW
XSN1B UA1 VQUIET_B EN_N ENB_N VDPWR VGND ELAD1_TGB
XSN4 UA4 OUT_B EN_N ENB_N VDPWR VGND ELAD1_TSW
XCL_VQ_A VQUIET_A CLR_N VGND ELAD1_CLAMP
XCL_VQ_B VQUIET_B CLR_N VGND ELAD1_CLAMP
XINV_MG EN_MG ENB_MG VDPWR VGND ELAD1_INV
XINV_MC EN_MC ENB_MC VDPWR VGND ELAD1_INV
XINV_PG EN_PG ENB_PG VDPWR VGND ELAD1_INV
XINV_PC EN_PC ENB_PC VDPWR VGND ELAD1_INV
XINV_N EN_N ENB_N VDPWR VGND ELAD1_INV
.ends


* expanding   symbol:  ELAD1_MIRROR_GROUPED.sym # of pins=3
** sym_path: cells/ELAD1_MIRROR_GROUPED/schematic/ELAD1_MIRROR_GROUPED.sym
** sch_path: cells/ELAD1_MIRROR_GROUPED/schematic/ELAD1_MIRROR_GROUPED.sch
.subckt ELAD1_MIRROR_GROUPED REF OUT VGND
*.iopin REF
*.iopin OUT
*.iopin VGND
XA[3] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[2] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[1] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[0] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[3] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[2] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[1] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[0] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[15] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[14] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[13] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[12] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[11] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[10] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[9] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[8] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[7] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[6] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[5] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[4] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[3] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[2] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[1] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[0] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_MIRROR_CC.sym # of pins=3
** sym_path: cells/ELAD1_MIRROR_CC/schematic/ELAD1_MIRROR_CC.sym
** sch_path: cells/ELAD1_MIRROR_CC/schematic/ELAD1_MIRROR_CC.sch
.subckt ELAD1_MIRROR_CC REF OUT VGND
*.iopin REF
*.iopin OUT
*.iopin VGND
XA[3] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[2] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[1] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[0] REF REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[3] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[2] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[1] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[0] OUT REF VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[15] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[14] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[13] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[12] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[11] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[10] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[9] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[8] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[7] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[6] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[5] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[4] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[3] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[2] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[1] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[0] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_PAIR_GROUPED.sym # of pins=6
** sym_path: cells/ELAD1_PAIR_GROUPED/schematic/ELAD1_PAIR_GROUPED.sym
** sch_path: cells/ELAD1_PAIR_GROUPED/schematic/ELAD1_PAIR_GROUPED.sch
.subckt ELAD1_PAIR_GROUPED VINP VINM D1 D2 VBIAS VGND
*.iopin VINP
*.iopin VINM
*.iopin D1
*.iopin D2
*.iopin VBIAS
*.iopin VGND
XA0 D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA1 D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA2 D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA3 D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB0 D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB1 D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB2 D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB3 D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT0 TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT1 TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT2 TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT3 TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR0 VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR1 VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR2 VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR3 VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM0 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM1 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM2 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM3 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM4 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM5 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM6 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM7 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM8 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM9 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM10 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM11 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM12 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM13 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM14 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM15 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM16 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM17 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM18 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM19 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM20 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM21 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM22 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM23 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM24 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM25 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM26 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM27 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM28 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM29 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM30 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM31 VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_PAIR_CC.sym # of pins=6
** sym_path: cells/ELAD1_PAIR_CC/schematic/ELAD1_PAIR_CC.sym
** sch_path: cells/ELAD1_PAIR_CC/schematic/ELAD1_PAIR_CC.sch
.subckt ELAD1_PAIR_CC VINP VINM D1 D2 VBIAS VGND
*.iopin D1
*.iopin D2
*.iopin VINP
*.iopin VINM
*.iopin VBIAS
*.iopin VGND
XA[3] D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[2] D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[1] D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XA[0] D1 VINP TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[3] D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[2] D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[1] D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XB[0] D2 VINM TAIL VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT[3] TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT[2] TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT[1] TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XT[0] TAIL VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR[3] VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR[2] VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR[1] VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XR[0] VBIAS VBIAS VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[31] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[30] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[29] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[28] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[27] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[26] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[25] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[24] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[23] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[22] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[21] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[20] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[19] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[18] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[17] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[16] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[15] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[14] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[13] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[12] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[11] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[10] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XDUM[9] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[8] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[7] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[6] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[5] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[4] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[3] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[2] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[1] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[0] VGND VGND VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_VICTIM_BASELINE.sym # of pins=5
** sym_path: cells/ELAD1_VICTIM_BASELINE/schematic/ELAD1_VICTIM_BASELINE.sym
** sch_path: cells/ELAD1_VICTIM_BASELINE/schematic/ELAD1_VICTIM_BASELINE.sch
.subckt ELAD1_VICTIM_BASELINE VQUIET OUT VDPWR VGND SUBQ
*.iopin VQUIET
*.iopin OUT
*.iopin VDPWR
*.iopin VGND
*.iopin SUBQ
XMVIC[1] OUT VQUIET VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XMVIC[0] OUT VQUIET VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XMD[1] VGND VGND VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=2 m=2
XMD[0] VGND VGND VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=2 m=2
XR1 OUT VDPWR SUBQ sky130_fd_pr__res_xhigh_po_0p69 L=31.7 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_VICTIM_GUARDED.sym # of pins=5
** sym_path: cells/ELAD1_VICTIM_GUARDED/schematic/ELAD1_VICTIM_GUARDED.sym
** sch_path: cells/ELAD1_VICTIM_GUARDED/schematic/ELAD1_VICTIM_GUARDED.sch
.subckt ELAD1_VICTIM_GUARDED VQUIET OUT VDPWR VGND SUBQ
*.iopin VQUIET
*.iopin OUT
*.iopin VDPWR
*.iopin VGND
*.iopin SUBQ
XRLD VDPWR OUT SUBQ sky130_fd_pr__res_xhigh_po W=0.69 L=31.7 mult=1 m=1
XMVIC OUT VQUIET VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[1] VGND VGND VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XDUM[0] VGND VGND VGND SUBQ sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_HEATER.sym # of pins=3
** sym_path: cells/ELAD1_HEATER/schematic/ELAD1_HEATER.sym
** sch_path: cells/ELAD1_HEATER/schematic/ELAD1_HEATER.sch
.subckt ELAD1_HEATER HIN HEN VGND
*.iopin HIN
*.iopin HEN
*.iopin VGND
XRH0 HIN HD VGND sky130_fd_pr__res_high_po W=5.73 L=52.9 mult=1 m=1
XRH1 HIN HD VGND sky130_fd_pr__res_high_po W=5.73 L=52.9 mult=1 m=1
XMSW HD HEN VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=40 nf=1 ad='int((1 + 1)/2) * 40 / 1 * 0.29' as='int((1 + 2)/2) * 40 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (40 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (40 / 1 + 0.29)' nrd='0.29 / 40 ' nrs='0.29 / 40 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_AGGRESSOR.sym # of pins=3
** sym_path: cells/ELAD1_AGGRESSOR/schematic/ELAD1_AGGRESSOR.sym
** sch_path: cells/ELAD1_AGGRESSOR/schematic/ELAD1_AGGRESSOR.sch
.subckt ELAD1_AGGRESSOR AGG_CLK VDPWR VGND
*.iopin AGG_CLK
*.iopin VDPWR
*.iopin VGND
XB1P b1 AGG_CLK VDPWR VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XB1N b1 AGG_CLK VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=0.65 nf=1 ad='int((1 + 1)/2) * 0.65 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.65 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.65 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.65 / 1 + 0.29)'
+ nrd='0.29 / 0.65 ' nrs='0.29 / 0.65 ' sa=0 sb=0 sd=0 mult=1 m=1
XB2P b2 b1 VDPWR VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=4 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XB2N b2 b1 VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XIP[3] o3 b2 VDPWR VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=4 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XIP[2] o2 b2 VDPWR VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=4 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XIP[1] o1 b2 VDPWR VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=4 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XIP[0] o0 b2 VDPWR VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=4 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XIN[3] o3 b2 VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XIN[2] o2 b2 VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XIN[1] o1 b2 VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XIN[0] o0 b2 VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XC[3] VGND o3 VGND VGND sky130_fd_pr__nfet_01v8 L=4 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1 + 2)/2) * 5 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29 / 5 ' nrs='0.29 / 5 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XC[2] VGND o2 VGND VGND sky130_fd_pr__nfet_01v8 L=4 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1 + 2)/2) * 5 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29 / 5 ' nrs='0.29 / 5 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XC[1] VGND o1 VGND VGND sky130_fd_pr__nfet_01v8 L=4 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1 + 2)/2) * 5 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29 / 5 ' nrs='0.29 / 5 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XC[0] VGND o0 VGND VGND sky130_fd_pr__nfet_01v8 L=4 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1 + 2)/2) * 5 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29 / 5 ' nrs='0.29 / 5 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_TGA.sym # of pins=6
** sym_path: cells/ELAD1_TGA/schematic/ELAD1_TGA.sym
** sch_path: cells/ELAD1_TGA/schematic/ELAD1_TGA.sch
.subckt ELAD1_TGA A B EN ENB VDPWR VGND
*.iopin A
*.iopin B
*.iopin EN
*.iopin ENB
*.iopin VDPWR
*.iopin VGND
XMN A EN B VGND sky130_fd_pr__nfet_01v8_lvt L=0.15 W=4 nf=1 ad='int((1 + 1)/2) * 4 / 1 * 0.29' as='int((1 + 2)/2) * 4 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (4 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (4 / 1 + 0.29)' nrd='0.29 / 4 ' nrs='0.29 / 4 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMP A ENB B VDPWR sky130_fd_pr__pfet_01v8_lvt L=0.35 W=12 nf=1 ad='int((1 + 1)/2) * 12 / 1 * 0.29' as='int((1 + 2)/2) * 12 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (12 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (12 / 1 + 0.29)' nrd='0.29 / 12 ' nrs='0.29 / 12 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_TGB.sym # of pins=6
** sym_path: cells/ELAD1_TGB/schematic/ELAD1_TGB.sym
** sch_path: cells/ELAD1_TGB/schematic/ELAD1_TGB.sch
.subckt ELAD1_TGB A B EN ENB VDPWR VGND
*.iopin A
*.iopin B
*.iopin EN
*.iopin ENB
*.iopin VDPWR
*.iopin VGND
XMN A EN B VGND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMP A ENB B VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_CLAMP.sym # of pins=3
** sym_path: cells/ELAD1_CLAMP/schematic/ELAD1_CLAMP.sym
** sch_path: cells/ELAD1_CLAMP/schematic/ELAD1_CLAMP.sch
.subckt ELAD1_CLAMP NODE CLR VGND
*.iopin NODE
*.iopin CLR
*.iopin VGND
XM NODE CLR VGND VGND sky130_fd_pr__nfet_01v8 L=1 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29' as='int((1 + 2)/2) * 0.42 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)' nrd='0.29 / 0.42 '
+ nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_TSW.sym # of pins=6
** sym_path: cells/ELAD1_TSW/schematic/ELAD1_TSW.sym
** sch_path: cells/ELAD1_TSW/schematic/ELAD1_TSW.sch
.subckt ELAD1_TSW A B EN ENB VDPWR VGND
*.iopin A
*.iopin B
*.iopin EN
*.iopin ENB
*.iopin VDPWR
*.iopin VGND
X1 A M EN ENB VDPWR VGND ELAD1_TGA
X2 M B EN ENB VDPWR VGND ELAD1_TGA
XSH M ENB VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ELAD1_INV.sym # of pins=4
** sym_path: cells/ELAD1_INV/schematic/ELAD1_INV.sym
** sch_path: cells/ELAD1_INV/schematic/ELAD1_INV.sch
.subckt ELAD1_INV A Y VDPWR VGND
*.iopin A
*.iopin Y
*.iopin VDPWR
*.iopin VGND
XMP Y A VDPWR VDPWR sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XMN Y A VGND VGND sky130_fd_pr__nfet_01v8 L=0.15 W=0.65 nf=1 ad='int((1 + 1)/2) * 0.65 / 1 * 0.29' as='int((1 + 2)/2) * 0.65 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (0.65 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.65 / 1 + 0.29)' nrd='0.29 / 0.65 '
+ nrs='0.29 / 0.65 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL VGND
.end
