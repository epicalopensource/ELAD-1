v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 160 120 160 1140 {}
N 80 60 100 60 {}
N 220 60 240 60 {}
N 380 780 380 1140 {}
N 300 720 320 720 {}
N 440 720 460 720 {}
N 600 560 600 1140 {}
N 520 500 540 500 {}
N 660 500 680 500 {}
N 820 1000 820 1140 {}
N 740 940 760 940 {}
N 880 940 900 940 {}
N 160 1140 380 1140 {}
N 380 1140 380 1210 {}
N 380 1210 380 1310 {}
N 320 1370 320 1420 {}
N 600 1140 820 1140 {}
N 820 1140 820 1210 {}
N 1200 120 1200 1140 {}
N 1120 60 1140 60 {}
N 1260 60 1280 60 {}
N 1420 780 1420 1140 {}
N 1340 720 1360 720 {}
N 1480 720 1500 720 {}
N 1640 560 1640 1140 {}
N 1560 500 1580 500 {}
N 1700 500 1720 500 {}
N 1860 1000 1860 1140 {}
N 1780 940 1800 940 {}
N 1920 940 1940 940 {}
N 1200 1140 1420 1140 {}
N 1420 1140 1420 1210 {}
N 1420 1210 1420 1310 {}
N 1360 1370 1360 1420 {}
N 1640 1140 1860 1140 {}
N 1860 1140 1860 1210 {}
N 2240 120 2240 1140 {}
N 2160 60 2180 60 {}
N 2300 60 2320 60 {}
N 2460 340 2460 1140 {}
N 2380 280 2400 280 {}
N 2520 280 2540 280 {}
N 2680 560 2680 1140 {}
N 2600 500 2620 500 {}
N 2740 500 2760 500 {}
N 2900 780 2900 1140 {}
N 2820 720 2840 720 {}
N 2960 720 2980 720 {}
N 3120 1000 3120 1140 {}
N 3040 940 3060 940 {}
N 3180 940 3200 940 {}
N 2240 1140 2240 1210 {}
N 2240 1210 2240 1310 {}
N 2180 1370 2180 1420 {}
N 2460 1140 2460 1210 {}
N 2460 1210 2460 1310 {}
N 2400 1370 2400 1420 {}
N 2680 1140 2680 1210 {}
N 2680 1210 2680 1310 {}
N 2620 1370 2620 1420 {}
N 2900 1140 2900 1210 {}
N 3120 1140 3120 1210 {}
N 3500 120 3500 1140 {}
N 3420 60 3440 60 {}
N 3560 60 3580 60 {}
N 3720 340 3720 1140 {}
N 3640 280 3660 280 {}
N 3780 280 3800 280 {}
N 3940 560 3940 1140 {}
N 3860 500 3880 500 {}
N 4000 500 4020 500 {}
N 4160 780 4160 1140 {}
N 4080 720 4100 720 {}
N 4220 720 4240 720 {}
N 4380 1000 4380 1140 {}
N 4300 940 4320 940 {}
N 4440 940 4460 940 {}
N 3500 1140 3500 1210 {}
N 3500 1210 3500 1310 {}
N 3440 1370 3440 1420 {}
N 3720 1140 3720 1210 {}
N 3720 1210 3720 1310 {}
N 3660 1370 3660 1420 {}
N 3940 1140 3940 1210 {}
N 3940 1210 3940 1310 {}
N 3880 1370 3880 1420 {}
N 4160 1140 4160 1210 {}
N 4380 1140 4380 1210 {}
N 4760 120 4760 1140 {}
N 4680 60 4700 60 {}
N 4820 60 4840 60 {}
N 4980 560 4980 1140 {}
N 4900 500 4920 500 {}
N 5040 500 5060 500 {}
N 5200 340 5200 1140 {}
N 5120 280 5140 280 {}
N 5260 280 5280 280 {}
N 5420 780 5420 1140 {}
N 5340 720 5360 720 {}
N 5480 720 5500 720 {}
N 5640 340 5640 1140 {}
N 5560 280 5580 280 {}
N 5700 280 5720 280 {}
N 5860 1000 5860 1140 {}
N 5780 940 5800 940 {}
N 5920 940 5940 940 {}
N 4760 1140 4980 1140 {}
N 4980 1140 4980 1210 {}
N 5200 1140 5200 1210 {}
N 5200 1210 5200 1310 {}
N 5140 1370 5140 1420 {}
N 5420 1140 5420 1210 {}
N 5640 1140 5640 1210 {}
N 5640 1210 5640 1310 {}
N 5580 1370 5580 1420 {}
N 5860 1140 5860 1210 {}
N -300 0 160 0 {}
N 160 0 1200 0 {}
N 1200 0 2240 0 {}
N 2240 0 3500 0 {}
N 3500 0 4760 0 {}
N 4760 0 5900 0 {}
N -300 220 2460 220 {}
N 2460 220 3720 220 {}
N 3720 220 5200 220 {}
N 5200 220 5640 220 {}
N 5640 220 5900 220 {}
N -300 440 600 440 {}
N 600 440 1640 440 {}
N 1640 440 2680 440 {}
N 2680 440 3940 440 {}
N 3940 440 4980 440 {}
N 4980 440 5900 440 {}
N -300 660 380 660 {}
N 380 660 1420 660 {}
N 1420 660 2900 660 {}
N 2900 660 4160 660 {}
N 4160 660 5420 660 {}
N 5420 660 5900 660 {}
N -300 880 820 880 {}
N 820 880 1860 880 {}
N 1860 880 3120 880 {}
N 3120 880 4380 880 {}
N 4380 880 5860 880 {}
N 5860 880 5900 880 {}
N -300 1570 -160 1570 {}
N -160 1570 -120 1570 {}
N 0 1570 60 1570 {}
N 300 1570 380 1570 {}
N -300 1730 -160 1730 {}
N -160 1730 -120 1730 {}
N 0 1730 60 1730 {}
N 300 1730 380 1730 {}
N -300 1890 -160 1890 {}
N -160 1890 -120 1890 {}
N 0 1890 60 1890 {}
N 300 1890 380 1890 {}
N -300 2050 -160 2050 {}
N -160 2050 -120 2050 {}
N 0 2050 60 2050 {}
N 300 2050 380 2050 {}
N -300 2210 -160 2210 {}
N -160 2210 -120 2210 {}
N 0 2210 60 2210 {}
N 300 2210 380 2210 {}
N -300 2370 -200 2370 {}
N -300 2450 -200 2450 {}
C {devices/iopin.sym} -300 0 0 1 {name=p155 lab=UA0}
C {devices/iopin.sym} -300 220 0 1 {name=p156 lab=UA1}
C {devices/iopin.sym} -300 440 0 1 {name=p157 lab=UA2}
C {devices/iopin.sym} -300 660 0 1 {name=p158 lab=UA3}
C {devices/iopin.sym} -300 880 0 1 {name=p159 lab=UA4}
C {devices/iopin.sym} 380 1210 0 0 {name=p17 lab=REF_G}
C {devices/iopin.sym} 820 1210 0 0 {name=p21 lab=OUT_G}
C {devices/iopin.sym} 1420 1210 0 0 {name=p39 lab=REF_C}
C {devices/iopin.sym} 1860 1210 0 0 {name=p43 lab=OUT_C}
C {devices/iopin.sym} 2240 1210 0 0 {name=p65 lab=VBIAS_G}
C {devices/iopin.sym} 2460 1210 0 0 {name=p69 lab=VINP_G}
C {devices/iopin.sym} 2680 1210 0 0 {name=p73 lab=VINM_G}
C {devices/iopin.sym} 2900 1210 0 0 {name=p77 lab=D1_G}
C {devices/iopin.sym} 3120 1210 0 0 {name=p79 lab=D2_G}
C {devices/iopin.sym} 3500 1210 0 0 {name=p101 lab=VBIAS_C}
C {devices/iopin.sym} 3720 1210 0 0 {name=p105 lab=VINP_C}
C {devices/iopin.sym} 3940 1210 0 0 {name=p109 lab=VINM_C}
C {devices/iopin.sym} 4160 1210 0 0 {name=p113 lab=D1_C}
C {devices/iopin.sym} 4380 1210 0 0 {name=p115 lab=D2_C}
C {devices/iopin.sym} 5200 1210 0 0 {name=p143 lab=VQUIET_A}
C {devices/iopin.sym} 5640 1210 0 0 {name=p149 lab=VQUIET_B}
C {devices/iopin.sym} 5420 1210 0 0 {name=p147 lab=OUT_A}
C {devices/iopin.sym} 5860 1210 0 0 {name=p153 lab=OUT_B}
C {devices/iopin.sym} 4980 1210 0 0 {name=p141 lab=SUBI}
C {devices/iopin.sym} -300 1570 0 1 {name=p160 lab=EN_MG}
C {devices/iopin.sym} -300 1730 0 1 {name=p167 lab=EN_MC}
C {devices/iopin.sym} -300 1890 0 1 {name=p174 lab=EN_PG}
C {devices/iopin.sym} -300 2050 0 1 {name=p181 lab=EN_PC}
C {devices/iopin.sym} -300 2210 0 1 {name=p188 lab=EN_N}
C {devices/iopin.sym} 300 1570 0 1 {name=p165 lab=CLR_MG}
C {devices/iopin.sym} 300 1730 0 1 {name=p172 lab=CLR_MC}
C {devices/iopin.sym} 300 1890 0 1 {name=p179 lab=CLR_PG}
C {devices/iopin.sym} 300 2050 0 1 {name=p186 lab=CLR_PC}
C {devices/iopin.sym} 300 2210 0 1 {name=p193 lab=CLR_N}
C {devices/iopin.sym} -300 2370 0 1 {name=p195 lab=VDPWR}
C {devices/iopin.sym} -300 2450 0 1 {name=p197 lab=VGND}
C {ELAD1_TGA.sym} 160 60 1 0 {name=XSMG0}
C {devices/lab_pin.sym} 80 60 0 0 {name=l1 sig_type=std_logic lab=EN_MG}
C {devices/lab_pin.sym} 240 60 0 1 {name=l2 sig_type=std_logic lab=ENB_MG}
C {devices/vdd.sym} 220 100 0 0 {name=l3 lab=VDPWR global=false}
C {devices/gnd.sym} 100 100 0 0 {name=l4 lab=VGND global=false}
C {ELAD1_TGB.sym} 380 720 1 0 {name=XSMG3}
C {devices/lab_pin.sym} 300 720 0 0 {name=l5 sig_type=std_logic lab=EN_MG}
C {devices/lab_pin.sym} 460 720 0 1 {name=l6 sig_type=std_logic lab=ENB_MG}
C {devices/vdd.sym} 440 760 0 0 {name=l7 lab=VDPWR global=false}
C {devices/gnd.sym} 320 760 0 0 {name=l8 lab=VGND global=false}
C {ELAD1_TGB.sym} 600 500 1 0 {name=XSMG2}
C {devices/lab_pin.sym} 520 500 0 0 {name=l9 sig_type=std_logic lab=EN_MG}
C {devices/lab_pin.sym} 680 500 0 1 {name=l10 sig_type=std_logic lab=ENB_MG}
C {devices/vdd.sym} 660 540 0 0 {name=l11 lab=VDPWR global=false}
C {devices/gnd.sym} 540 540 0 0 {name=l12 lab=VGND global=false}
C {ELAD1_TGA.sym} 820 940 1 0 {name=XSMG4}
C {devices/lab_pin.sym} 740 940 0 0 {name=l13 sig_type=std_logic lab=EN_MG}
C {devices/lab_pin.sym} 900 940 0 1 {name=l14 sig_type=std_logic lab=ENB_MG}
C {devices/vdd.sym} 880 980 0 0 {name=l15 lab=VDPWR global=false}
C {devices/gnd.sym} 760 980 0 0 {name=l16 lab=VGND global=false}
C {devices/lab_pin.sym} 380 1140 0 1 {name=l18 sig_type=std_logic lab=REF_G}
C {ELAD1_CLAMP.sym} 380 1370 0 0 {name=XCL_REF_G}
C {devices/lab_pin.sym} 320 1420 0 0 {name=l19 sig_type=std_logic lab=CLR_MG}
C {devices/gnd.sym} 380 1430 0 0 {name=l20 lab=VGND global=false}
C {devices/lab_pin.sym} 820 1140 0 1 {name=l22 sig_type=std_logic lab=OUT_G}
C {ELAD1_TGA.sym} 1200 60 1 0 {name=XSMC0}
C {devices/lab_pin.sym} 1120 60 0 0 {name=l23 sig_type=std_logic lab=EN_MC}
C {devices/lab_pin.sym} 1280 60 0 1 {name=l24 sig_type=std_logic lab=ENB_MC}
C {devices/vdd.sym} 1260 100 0 0 {name=l25 lab=VDPWR global=false}
C {devices/gnd.sym} 1140 100 0 0 {name=l26 lab=VGND global=false}
C {ELAD1_TGB.sym} 1420 720 1 0 {name=XSMC3}
C {devices/lab_pin.sym} 1340 720 0 0 {name=l27 sig_type=std_logic lab=EN_MC}
C {devices/lab_pin.sym} 1500 720 0 1 {name=l28 sig_type=std_logic lab=ENB_MC}
C {devices/vdd.sym} 1480 760 0 0 {name=l29 lab=VDPWR global=false}
C {devices/gnd.sym} 1360 760 0 0 {name=l30 lab=VGND global=false}
C {ELAD1_TGB.sym} 1640 500 1 0 {name=XSMC2}
C {devices/lab_pin.sym} 1560 500 0 0 {name=l31 sig_type=std_logic lab=EN_MC}
C {devices/lab_pin.sym} 1720 500 0 1 {name=l32 sig_type=std_logic lab=ENB_MC}
C {devices/vdd.sym} 1700 540 0 0 {name=l33 lab=VDPWR global=false}
C {devices/gnd.sym} 1580 540 0 0 {name=l34 lab=VGND global=false}
C {ELAD1_TGA.sym} 1860 940 1 0 {name=XSMC4}
C {devices/lab_pin.sym} 1780 940 0 0 {name=l35 sig_type=std_logic lab=EN_MC}
C {devices/lab_pin.sym} 1940 940 0 1 {name=l36 sig_type=std_logic lab=ENB_MC}
C {devices/vdd.sym} 1920 980 0 0 {name=l37 lab=VDPWR global=false}
C {devices/gnd.sym} 1800 980 0 0 {name=l38 lab=VGND global=false}
C {devices/lab_pin.sym} 1420 1140 0 1 {name=l40 sig_type=std_logic lab=REF_C}
C {ELAD1_CLAMP.sym} 1420 1370 0 0 {name=XCL_REF_C}
C {devices/lab_pin.sym} 1360 1420 0 0 {name=l41 sig_type=std_logic lab=CLR_MC}
C {devices/gnd.sym} 1420 1430 0 0 {name=l42 lab=VGND global=false}
C {devices/lab_pin.sym} 1860 1140 0 1 {name=l44 sig_type=std_logic lab=OUT_C}
C {ELAD1_TGA.sym} 2240 60 1 0 {name=XSPG0}
C {devices/lab_pin.sym} 2160 60 0 0 {name=l45 sig_type=std_logic lab=EN_PG}
C {devices/lab_pin.sym} 2320 60 0 1 {name=l46 sig_type=std_logic lab=ENB_PG}
C {devices/vdd.sym} 2300 100 0 0 {name=l47 lab=VDPWR global=false}
C {devices/gnd.sym} 2180 100 0 0 {name=l48 lab=VGND global=false}
C {ELAD1_TGB.sym} 2460 280 1 0 {name=XSPG1}
C {devices/lab_pin.sym} 2380 280 0 0 {name=l49 sig_type=std_logic lab=EN_PG}
C {devices/lab_pin.sym} 2540 280 0 1 {name=l50 sig_type=std_logic lab=ENB_PG}
C {devices/vdd.sym} 2520 320 0 0 {name=l51 lab=VDPWR global=false}
C {devices/gnd.sym} 2400 320 0 0 {name=l52 lab=VGND global=false}
C {ELAD1_TGB.sym} 2680 500 1 0 {name=XSPG2}
C {devices/lab_pin.sym} 2600 500 0 0 {name=l53 sig_type=std_logic lab=EN_PG}
C {devices/lab_pin.sym} 2760 500 0 1 {name=l54 sig_type=std_logic lab=ENB_PG}
C {devices/vdd.sym} 2740 540 0 0 {name=l55 lab=VDPWR global=false}
C {devices/gnd.sym} 2620 540 0 0 {name=l56 lab=VGND global=false}
C {ELAD1_TGA.sym} 2900 720 1 0 {name=XSPG3}
C {devices/lab_pin.sym} 2820 720 0 0 {name=l57 sig_type=std_logic lab=EN_PG}
C {devices/lab_pin.sym} 2980 720 0 1 {name=l58 sig_type=std_logic lab=ENB_PG}
C {devices/vdd.sym} 2960 760 0 0 {name=l59 lab=VDPWR global=false}
C {devices/gnd.sym} 2840 760 0 0 {name=l60 lab=VGND global=false}
C {ELAD1_TGA.sym} 3120 940 1 0 {name=XSPG4}
C {devices/lab_pin.sym} 3040 940 0 0 {name=l61 sig_type=std_logic lab=EN_PG}
C {devices/lab_pin.sym} 3200 940 0 1 {name=l62 sig_type=std_logic lab=ENB_PG}
C {devices/vdd.sym} 3180 980 0 0 {name=l63 lab=VDPWR global=false}
C {devices/gnd.sym} 3060 980 0 0 {name=l64 lab=VGND global=false}
C {devices/lab_pin.sym} 2240 1140 0 1 {name=l66 sig_type=std_logic lab=VBIAS_G}
C {ELAD1_CLAMP.sym} 2240 1370 0 0 {name=XCL_VBIAS_G}
C {devices/lab_pin.sym} 2180 1420 0 0 {name=l67 sig_type=std_logic lab=CLR_PG}
C {devices/gnd.sym} 2240 1430 0 0 {name=l68 lab=VGND global=false}
C {devices/lab_pin.sym} 2460 1140 0 1 {name=l70 sig_type=std_logic lab=VINP_G}
C {ELAD1_CLAMP.sym} 2460 1370 0 0 {name=XCL_VINP_G}
C {devices/lab_pin.sym} 2400 1420 0 0 {name=l71 sig_type=std_logic lab=CLR_PG}
C {devices/gnd.sym} 2460 1430 0 0 {name=l72 lab=VGND global=false}
C {devices/lab_pin.sym} 2680 1140 0 1 {name=l74 sig_type=std_logic lab=VINM_G}
C {ELAD1_CLAMP.sym} 2680 1370 0 0 {name=XCL_VINM_G}
C {devices/lab_pin.sym} 2620 1420 0 0 {name=l75 sig_type=std_logic lab=CLR_PG}
C {devices/gnd.sym} 2680 1430 0 0 {name=l76 lab=VGND global=false}
C {devices/lab_pin.sym} 2900 1140 0 1 {name=l78 sig_type=std_logic lab=D1_G}
C {devices/lab_pin.sym} 3120 1140 0 1 {name=l80 sig_type=std_logic lab=D2_G}
C {ELAD1_TGA.sym} 3500 60 1 0 {name=XSPC0}
C {devices/lab_pin.sym} 3420 60 0 0 {name=l81 sig_type=std_logic lab=EN_PC}
C {devices/lab_pin.sym} 3580 60 0 1 {name=l82 sig_type=std_logic lab=ENB_PC}
C {devices/vdd.sym} 3560 100 0 0 {name=l83 lab=VDPWR global=false}
C {devices/gnd.sym} 3440 100 0 0 {name=l84 lab=VGND global=false}
C {ELAD1_TGB.sym} 3720 280 1 0 {name=XSPC1}
C {devices/lab_pin.sym} 3640 280 0 0 {name=l85 sig_type=std_logic lab=EN_PC}
C {devices/lab_pin.sym} 3800 280 0 1 {name=l86 sig_type=std_logic lab=ENB_PC}
C {devices/vdd.sym} 3780 320 0 0 {name=l87 lab=VDPWR global=false}
C {devices/gnd.sym} 3660 320 0 0 {name=l88 lab=VGND global=false}
C {ELAD1_TGB.sym} 3940 500 1 0 {name=XSPC2}
C {devices/lab_pin.sym} 3860 500 0 0 {name=l89 sig_type=std_logic lab=EN_PC}
C {devices/lab_pin.sym} 4020 500 0 1 {name=l90 sig_type=std_logic lab=ENB_PC}
C {devices/vdd.sym} 4000 540 0 0 {name=l91 lab=VDPWR global=false}
C {devices/gnd.sym} 3880 540 0 0 {name=l92 lab=VGND global=false}
C {ELAD1_TGA.sym} 4160 720 1 0 {name=XSPC3}
C {devices/lab_pin.sym} 4080 720 0 0 {name=l93 sig_type=std_logic lab=EN_PC}
C {devices/lab_pin.sym} 4240 720 0 1 {name=l94 sig_type=std_logic lab=ENB_PC}
C {devices/vdd.sym} 4220 760 0 0 {name=l95 lab=VDPWR global=false}
C {devices/gnd.sym} 4100 760 0 0 {name=l96 lab=VGND global=false}
C {ELAD1_TGA.sym} 4380 940 1 0 {name=XSPC4}
C {devices/lab_pin.sym} 4300 940 0 0 {name=l97 sig_type=std_logic lab=EN_PC}
C {devices/lab_pin.sym} 4460 940 0 1 {name=l98 sig_type=std_logic lab=ENB_PC}
C {devices/vdd.sym} 4440 980 0 0 {name=l99 lab=VDPWR global=false}
C {devices/gnd.sym} 4320 980 0 0 {name=l100 lab=VGND global=false}
C {devices/lab_pin.sym} 3500 1140 0 1 {name=l102 sig_type=std_logic lab=VBIAS_C}
C {ELAD1_CLAMP.sym} 3500 1370 0 0 {name=XCL_VBIAS_C}
C {devices/lab_pin.sym} 3440 1420 0 0 {name=l103 sig_type=std_logic lab=CLR_PC}
C {devices/gnd.sym} 3500 1430 0 0 {name=l104 lab=VGND global=false}
C {devices/lab_pin.sym} 3720 1140 0 1 {name=l106 sig_type=std_logic lab=VINP_C}
C {ELAD1_CLAMP.sym} 3720 1370 0 0 {name=XCL_VINP_C}
C {devices/lab_pin.sym} 3660 1420 0 0 {name=l107 sig_type=std_logic lab=CLR_PC}
C {devices/gnd.sym} 3720 1430 0 0 {name=l108 lab=VGND global=false}
C {devices/lab_pin.sym} 3940 1140 0 1 {name=l110 sig_type=std_logic lab=VINM_C}
C {ELAD1_CLAMP.sym} 3940 1370 0 0 {name=XCL_VINM_C}
C {devices/lab_pin.sym} 3880 1420 0 0 {name=l111 sig_type=std_logic lab=CLR_PC}
C {devices/gnd.sym} 3940 1430 0 0 {name=l112 lab=VGND global=false}
C {devices/lab_pin.sym} 4160 1140 0 1 {name=l114 sig_type=std_logic lab=D1_C}
C {devices/lab_pin.sym} 4380 1140 0 1 {name=l116 sig_type=std_logic lab=D2_C}
C {ELAD1_TGB.sym} 4760 60 1 0 {name=XSN0}
C {devices/lab_pin.sym} 4680 60 0 0 {name=l117 sig_type=std_logic lab=EN_N}
C {devices/lab_pin.sym} 4840 60 0 1 {name=l118 sig_type=std_logic lab=ENB_N}
C {devices/vdd.sym} 4820 100 0 0 {name=l119 lab=VDPWR global=false}
C {devices/gnd.sym} 4700 100 0 0 {name=l120 lab=VGND global=false}
C {ELAD1_TGB.sym} 4980 500 1 0 {name=XSN2}
C {devices/lab_pin.sym} 4900 500 0 0 {name=l121 sig_type=std_logic lab=EN_N}
C {devices/lab_pin.sym} 5060 500 0 1 {name=l122 sig_type=std_logic lab=ENB_N}
C {devices/vdd.sym} 5040 540 0 0 {name=l123 lab=VDPWR global=false}
C {devices/gnd.sym} 4920 540 0 0 {name=l124 lab=VGND global=false}
C {ELAD1_TGB.sym} 5200 280 1 0 {name=XSN1A}
C {devices/lab_pin.sym} 5120 280 0 0 {name=l125 sig_type=std_logic lab=EN_N}
C {devices/lab_pin.sym} 5280 280 0 1 {name=l126 sig_type=std_logic lab=ENB_N}
C {devices/vdd.sym} 5260 320 0 0 {name=l127 lab=VDPWR global=false}
C {devices/gnd.sym} 5140 320 0 0 {name=l128 lab=VGND global=false}
C {ELAD1_TSW.sym} 5420 720 1 0 {name=XSN3}
C {devices/lab_pin.sym} 5340 720 0 0 {name=l129 sig_type=std_logic lab=EN_N}
C {devices/lab_pin.sym} 5500 720 0 1 {name=l130 sig_type=std_logic lab=ENB_N}
C {devices/vdd.sym} 5480 760 0 0 {name=l131 lab=VDPWR global=false}
C {devices/gnd.sym} 5360 760 0 0 {name=l132 lab=VGND global=false}
C {ELAD1_TGB.sym} 5640 280 1 0 {name=XSN1B}
C {devices/lab_pin.sym} 5560 280 0 0 {name=l133 sig_type=std_logic lab=EN_N}
C {devices/lab_pin.sym} 5720 280 0 1 {name=l134 sig_type=std_logic lab=ENB_N}
C {devices/vdd.sym} 5700 320 0 0 {name=l135 lab=VDPWR global=false}
C {devices/gnd.sym} 5580 320 0 0 {name=l136 lab=VGND global=false}
C {ELAD1_TSW.sym} 5860 940 1 0 {name=XSN4}
C {devices/lab_pin.sym} 5780 940 0 0 {name=l137 sig_type=std_logic lab=EN_N}
C {devices/lab_pin.sym} 5940 940 0 1 {name=l138 sig_type=std_logic lab=ENB_N}
C {devices/vdd.sym} 5920 980 0 0 {name=l139 lab=VDPWR global=false}
C {devices/gnd.sym} 5800 980 0 0 {name=l140 lab=VGND global=false}
C {devices/lab_pin.sym} 4980 1140 0 1 {name=l142 sig_type=std_logic lab=SUBI}
C {devices/lab_pin.sym} 5200 1140 0 1 {name=l144 sig_type=std_logic lab=VQUIET_A}
C {ELAD1_CLAMP.sym} 5200 1370 0 0 {name=XCL_VQ_A}
C {devices/lab_pin.sym} 5140 1420 0 0 {name=l145 sig_type=std_logic lab=CLR_N}
C {devices/gnd.sym} 5200 1430 0 0 {name=l146 lab=VGND global=false}
C {devices/lab_pin.sym} 5420 1140 0 1 {name=l148 sig_type=std_logic lab=OUT_A}
C {devices/lab_pin.sym} 5640 1140 0 1 {name=l150 sig_type=std_logic lab=VQUIET_B}
C {ELAD1_CLAMP.sym} 5640 1370 0 0 {name=XCL_VQ_B}
C {devices/lab_pin.sym} 5580 1420 0 0 {name=l151 sig_type=std_logic lab=CLR_N}
C {devices/gnd.sym} 5640 1430 0 0 {name=l152 lab=VGND global=false}
C {devices/lab_pin.sym} 5860 1140 0 1 {name=l154 sig_type=std_logic lab=OUT_B}
C {ELAD1_INV.sym} -60 1570 0 0 {name=XINV_MG}
C {devices/lab_pin.sym} -160 1570 0 1 {name=l161 sig_type=std_logic lab=EN_MG}
C {devices/lab_pin.sym} 60 1570 0 1 {name=l162 sig_type=std_logic lab=ENB_MG}
C {devices/vdd.sym} -60 1520 0 0 {name=l163 lab=VDPWR global=false}
C {devices/gnd.sym} -60 1620 0 0 {name=l164 lab=VGND global=false}
C {devices/lab_pin.sym} 380 1570 0 1 {name=l166 sig_type=std_logic lab=CLR_MG}
C {ELAD1_INV.sym} -60 1730 0 0 {name=XINV_MC}
C {devices/lab_pin.sym} -160 1730 0 1 {name=l168 sig_type=std_logic lab=EN_MC}
C {devices/lab_pin.sym} 60 1730 0 1 {name=l169 sig_type=std_logic lab=ENB_MC}
C {devices/vdd.sym} -60 1680 0 0 {name=l170 lab=VDPWR global=false}
C {devices/gnd.sym} -60 1780 0 0 {name=l171 lab=VGND global=false}
C {devices/lab_pin.sym} 380 1730 0 1 {name=l173 sig_type=std_logic lab=CLR_MC}
C {ELAD1_INV.sym} -60 1890 0 0 {name=XINV_PG}
C {devices/lab_pin.sym} -160 1890 0 1 {name=l175 sig_type=std_logic lab=EN_PG}
C {devices/lab_pin.sym} 60 1890 0 1 {name=l176 sig_type=std_logic lab=ENB_PG}
C {devices/vdd.sym} -60 1840 0 0 {name=l177 lab=VDPWR global=false}
C {devices/gnd.sym} -60 1940 0 0 {name=l178 lab=VGND global=false}
C {devices/lab_pin.sym} 380 1890 0 1 {name=l180 sig_type=std_logic lab=CLR_PG}
C {ELAD1_INV.sym} -60 2050 0 0 {name=XINV_PC}
C {devices/lab_pin.sym} -160 2050 0 1 {name=l182 sig_type=std_logic lab=EN_PC}
C {devices/lab_pin.sym} 60 2050 0 1 {name=l183 sig_type=std_logic lab=ENB_PC}
C {devices/vdd.sym} -60 2000 0 0 {name=l184 lab=VDPWR global=false}
C {devices/gnd.sym} -60 2100 0 0 {name=l185 lab=VGND global=false}
C {devices/lab_pin.sym} 380 2050 0 1 {name=l187 sig_type=std_logic lab=CLR_PC}
C {ELAD1_INV.sym} -60 2210 0 0 {name=XINV_N}
C {devices/lab_pin.sym} -160 2210 0 1 {name=l189 sig_type=std_logic lab=EN_N}
C {devices/lab_pin.sym} 60 2210 0 1 {name=l190 sig_type=std_logic lab=ENB_N}
C {devices/vdd.sym} -60 2160 0 0 {name=l191 lab=VDPWR global=false}
C {devices/gnd.sym} -60 2260 0 0 {name=l192 lab=VGND global=false}
C {devices/lab_pin.sym} 380 2210 0 1 {name=l194 sig_type=std_logic lab=CLR_N}
C {devices/vdd.sym} -200 2370 0 0 {name=l196 lab=VDPWR global=false}
C {devices/gnd.sym} -200 2450 0 0 {name=l198 lab=VGND global=false}
T {MIRROR GROUPED: EN_MG / ENB_MG, clamps CLR_MG} 100 -150 0 0 0.3 0.3 {}
T {MIRROR CENTROID: EN_MC / ENB_MC, clamps CLR_MC} 1140 -150 0 0 0.3 0.3 {}
T {PAIR GROUPED: EN_PG / ENB_PG, clamps CLR_PG} 2180 -150 0 0 0.3 0.3 {}
T {PAIR CENTROID: EN_PC / ENB_PC, clamps CLR_PC} 3440 -150 0 0 0.3 0.3 {}
T {NOISE: EN_N / ENB_N, clamps CLR_N} 4700 -150 0 0 0.3 0.3 {}
T {ELAD1_ANALOG_SELECTOR: switch matrix from the pins UA0-UA4 to the test structures} -300 -330 0 0 0.5 0.5 {}
T {Each switch connects one UA row (top) to one target net (bottom) while its mode's EN is 1. Clamps hold unused gate nodes at VGND (CLR). TGA: low-Vt gate, TGB: standard gate, TSW: T-switch.} -300 -270 0 0 0.25 0.25 {}
