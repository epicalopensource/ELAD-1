v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ELAD1_INV.sym} 560 0 0 0 {name=XINV_MG}
C {ELAD1_INV.sym} 960 0 0 0 {name=XINV_MC}
C {ELAD1_INV.sym} 1360 0 0 0 {name=XINV_PG}
C {ELAD1_INV.sym} 1760 0 0 0 {name=XINV_PC}
C {ELAD1_INV.sym} 2160 0 0 0 {name=XINV_N}
C {ELAD1_TGA.sym} 2560 0 0 0 {name=XSMG0}
C {ELAD1_TGB.sym} 2960 0 0 0 {name=XSMG2}
C {ELAD1_TGB.sym} 3360 0 0 0 {name=XSMG3}
C {ELAD1_TGA.sym} 3760 0 0 0 {name=XSMG4}
C {ELAD1_TGA.sym} 4160 0 0 0 {name=XSMC0}
C {ELAD1_TGB.sym} 4560 0 0 0 {name=XSMC2}
C {ELAD1_TGB.sym} 4960 0 0 0 {name=XSMC3}
C {ELAD1_TGA.sym} 5360 0 0 0 {name=XSMC4}
C {ELAD1_TGA.sym} 5760 0 0 0 {name=XSPG0}
C {ELAD1_TGB.sym} 6160 0 0 0 {name=XSPG1}
C {ELAD1_TGB.sym} 6560 0 0 0 {name=XSPG2}
C {ELAD1_TGA.sym} 6960 0 0 0 {name=XSPG3}
C {ELAD1_TGA.sym} 7360 0 0 0 {name=XSPG4}
C {ELAD1_TGA.sym} 7760 0 0 0 {name=XSPC0}
C {ELAD1_TGB.sym} 8160 0 0 0 {name=XSPC1}
C {ELAD1_TGB.sym} 8560 0 0 0 {name=XSPC2}
C {ELAD1_TGA.sym} 8960 0 0 0 {name=XSPC3}
C {ELAD1_TGA.sym} 9360 0 0 0 {name=XSPC4}
C {ELAD1_TGB.sym} 9760 0 0 0 {name=XSN1A}
C {ELAD1_TGB.sym} 10160 0 0 0 {name=XSN1B}
C {ELAD1_TSW.sym} 10560 0 0 0 {name=XSN3}
C {ELAD1_TSW.sym} 10960 0 0 0 {name=XSN4}
C {ELAD1_CLAMP.sym} 11360 0 0 0 {name=XCL_REF_G}
C {ELAD1_CLAMP.sym} 11760 0 0 0 {name=XCL_REF_C}
C {ELAD1_CLAMP.sym} 12160 0 0 0 {name=XCL_VBIAS_G}
C {ELAD1_CLAMP.sym} 12560 0 0 0 {name=XCL_VINP_G}
C {ELAD1_CLAMP.sym} 12960 0 0 0 {name=XCL_VINM_G}
C {ELAD1_CLAMP.sym} 13360 0 0 0 {name=XCL_VBIAS_C}
C {ELAD1_CLAMP.sym} 13760 0 0 0 {name=XCL_VINP_C}
C {ELAD1_CLAMP.sym} 14160 0 0 0 {name=XCL_VINM_C}
C {ELAD1_CLAMP.sym} 14560 0 0 0 {name=XCL_VQ_A}
C {ELAD1_CLAMP.sym} 14960 0 0 0 {name=XCL_VQ_B}
N 640 -10 660 -10 {lab=VDPWR}
C {devices/lab_pin.sym} 660 -10 0 1 {name=l1 sig_type=std_logic lab=VDPWR}
N 1040 -10 1060 -10 {lab=VDPWR}
C {devices/lab_pin.sym} 1060 -10 0 1 {name=l2 sig_type=std_logic lab=VDPWR}
N 1440 -10 1460 -10 {lab=VDPWR}
C {devices/lab_pin.sym} 1460 -10 0 1 {name=l3 sig_type=std_logic lab=VDPWR}
N 1840 -10 1860 -10 {lab=VDPWR}
C {devices/lab_pin.sym} 1860 -10 0 1 {name=l4 sig_type=std_logic lab=VDPWR}
N 2240 -10 2260 -10 {lab=VDPWR}
C {devices/lab_pin.sym} 2260 -10 0 1 {name=l5 sig_type=std_logic lab=VDPWR}
N 640 10 660 10 {lab=VGND}
C {devices/lab_pin.sym} 660 10 0 1 {name=l6 sig_type=std_logic lab=VGND}
N 1040 10 1060 10 {lab=VGND}
C {devices/lab_pin.sym} 1060 10 0 1 {name=l7 sig_type=std_logic lab=VGND}
N 1440 10 1460 10 {lab=VGND}
C {devices/lab_pin.sym} 1460 10 0 1 {name=l8 sig_type=std_logic lab=VGND}
N 1840 10 1860 10 {lab=VGND}
C {devices/lab_pin.sym} 1860 10 0 1 {name=l9 sig_type=std_logic lab=VGND}
N 2240 10 2260 10 {lab=VGND}
C {devices/lab_pin.sym} 2260 10 0 1 {name=l10 sig_type=std_logic lab=VGND}
N 2640 0 2660 0 {lab=VDPWR}
C {devices/lab_pin.sym} 2660 0 0 1 {name=l11 sig_type=std_logic lab=VDPWR}
N 3040 0 3060 0 {lab=VDPWR}
C {devices/lab_pin.sym} 3060 0 0 1 {name=l12 sig_type=std_logic lab=VDPWR}
N 3440 0 3460 0 {lab=VDPWR}
C {devices/lab_pin.sym} 3460 0 0 1 {name=l13 sig_type=std_logic lab=VDPWR}
N 3840 0 3860 0 {lab=VDPWR}
C {devices/lab_pin.sym} 3860 0 0 1 {name=l14 sig_type=std_logic lab=VDPWR}
N 4240 0 4260 0 {lab=VDPWR}
C {devices/lab_pin.sym} 4260 0 0 1 {name=l15 sig_type=std_logic lab=VDPWR}
N 4640 0 4660 0 {lab=VDPWR}
C {devices/lab_pin.sym} 4660 0 0 1 {name=l16 sig_type=std_logic lab=VDPWR}
N 5040 0 5060 0 {lab=VDPWR}
C {devices/lab_pin.sym} 5060 0 0 1 {name=l17 sig_type=std_logic lab=VDPWR}
N 5440 0 5460 0 {lab=VDPWR}
C {devices/lab_pin.sym} 5460 0 0 1 {name=l18 sig_type=std_logic lab=VDPWR}
N 5840 0 5860 0 {lab=VDPWR}
C {devices/lab_pin.sym} 5860 0 0 1 {name=l19 sig_type=std_logic lab=VDPWR}
N 6240 0 6260 0 {lab=VDPWR}
C {devices/lab_pin.sym} 6260 0 0 1 {name=l20 sig_type=std_logic lab=VDPWR}
N 6640 0 6660 0 {lab=VDPWR}
C {devices/lab_pin.sym} 6660 0 0 1 {name=l21 sig_type=std_logic lab=VDPWR}
N 7040 0 7060 0 {lab=VDPWR}
C {devices/lab_pin.sym} 7060 0 0 1 {name=l22 sig_type=std_logic lab=VDPWR}
N 7440 0 7460 0 {lab=VDPWR}
C {devices/lab_pin.sym} 7460 0 0 1 {name=l23 sig_type=std_logic lab=VDPWR}
N 7840 0 7860 0 {lab=VDPWR}
C {devices/lab_pin.sym} 7860 0 0 1 {name=l24 sig_type=std_logic lab=VDPWR}
N 8240 0 8260 0 {lab=VDPWR}
C {devices/lab_pin.sym} 8260 0 0 1 {name=l25 sig_type=std_logic lab=VDPWR}
N 8640 0 8660 0 {lab=VDPWR}
C {devices/lab_pin.sym} 8660 0 0 1 {name=l26 sig_type=std_logic lab=VDPWR}
N 9040 0 9060 0 {lab=VDPWR}
C {devices/lab_pin.sym} 9060 0 0 1 {name=l27 sig_type=std_logic lab=VDPWR}
N 9440 0 9460 0 {lab=VDPWR}
C {devices/lab_pin.sym} 9460 0 0 1 {name=l28 sig_type=std_logic lab=VDPWR}
N 9840 0 9860 0 {lab=VDPWR}
C {devices/lab_pin.sym} 9860 0 0 1 {name=l29 sig_type=std_logic lab=VDPWR}
N 10240 0 10260 0 {lab=VDPWR}
C {devices/lab_pin.sym} 10260 0 0 1 {name=l30 sig_type=std_logic lab=VDPWR}
N 10640 0 10660 0 {lab=VDPWR}
C {devices/lab_pin.sym} 10660 0 0 1 {name=l31 sig_type=std_logic lab=VDPWR}
N 11040 0 11060 0 {lab=VDPWR}
C {devices/lab_pin.sym} 11060 0 0 1 {name=l32 sig_type=std_logic lab=VDPWR}
N 2640 20 2660 20 {lab=VGND}
C {devices/lab_pin.sym} 2660 20 0 1 {name=l33 sig_type=std_logic lab=VGND}
N 3040 20 3060 20 {lab=VGND}
C {devices/lab_pin.sym} 3060 20 0 1 {name=l34 sig_type=std_logic lab=VGND}
N 3440 20 3460 20 {lab=VGND}
C {devices/lab_pin.sym} 3460 20 0 1 {name=l35 sig_type=std_logic lab=VGND}
N 3840 20 3860 20 {lab=VGND}
C {devices/lab_pin.sym} 3860 20 0 1 {name=l36 sig_type=std_logic lab=VGND}
N 4240 20 4260 20 {lab=VGND}
C {devices/lab_pin.sym} 4260 20 0 1 {name=l37 sig_type=std_logic lab=VGND}
N 4640 20 4660 20 {lab=VGND}
C {devices/lab_pin.sym} 4660 20 0 1 {name=l38 sig_type=std_logic lab=VGND}
N 5040 20 5060 20 {lab=VGND}
C {devices/lab_pin.sym} 5060 20 0 1 {name=l39 sig_type=std_logic lab=VGND}
N 5440 20 5460 20 {lab=VGND}
C {devices/lab_pin.sym} 5460 20 0 1 {name=l40 sig_type=std_logic lab=VGND}
N 5840 20 5860 20 {lab=VGND}
C {devices/lab_pin.sym} 5860 20 0 1 {name=l41 sig_type=std_logic lab=VGND}
N 6240 20 6260 20 {lab=VGND}
C {devices/lab_pin.sym} 6260 20 0 1 {name=l42 sig_type=std_logic lab=VGND}
N 6640 20 6660 20 {lab=VGND}
C {devices/lab_pin.sym} 6660 20 0 1 {name=l43 sig_type=std_logic lab=VGND}
N 7040 20 7060 20 {lab=VGND}
C {devices/lab_pin.sym} 7060 20 0 1 {name=l44 sig_type=std_logic lab=VGND}
N 7440 20 7460 20 {lab=VGND}
C {devices/lab_pin.sym} 7460 20 0 1 {name=l45 sig_type=std_logic lab=VGND}
N 7840 20 7860 20 {lab=VGND}
C {devices/lab_pin.sym} 7860 20 0 1 {name=l46 sig_type=std_logic lab=VGND}
N 8240 20 8260 20 {lab=VGND}
C {devices/lab_pin.sym} 8260 20 0 1 {name=l47 sig_type=std_logic lab=VGND}
N 8640 20 8660 20 {lab=VGND}
C {devices/lab_pin.sym} 8660 20 0 1 {name=l48 sig_type=std_logic lab=VGND}
N 9040 20 9060 20 {lab=VGND}
C {devices/lab_pin.sym} 9060 20 0 1 {name=l49 sig_type=std_logic lab=VGND}
N 9440 20 9460 20 {lab=VGND}
C {devices/lab_pin.sym} 9460 20 0 1 {name=l50 sig_type=std_logic lab=VGND}
N 9840 20 9860 20 {lab=VGND}
C {devices/lab_pin.sym} 9860 20 0 1 {name=l51 sig_type=std_logic lab=VGND}
N 10240 20 10260 20 {lab=VGND}
C {devices/lab_pin.sym} 10260 20 0 1 {name=l52 sig_type=std_logic lab=VGND}
N 10640 20 10660 20 {lab=VGND}
C {devices/lab_pin.sym} 10660 20 0 1 {name=l53 sig_type=std_logic lab=VGND}
N 11040 20 11060 20 {lab=VGND}
C {devices/lab_pin.sym} 11060 20 0 1 {name=l54 sig_type=std_logic lab=VGND}
N 11440 -10 11460 -10 {lab=VGND}
C {devices/lab_pin.sym} 11460 -10 0 1 {name=l55 sig_type=std_logic lab=VGND}
N 11840 -10 11860 -10 {lab=VGND}
C {devices/lab_pin.sym} 11860 -10 0 1 {name=l56 sig_type=std_logic lab=VGND}
N 12240 -10 12260 -10 {lab=VGND}
C {devices/lab_pin.sym} 12260 -10 0 1 {name=l57 sig_type=std_logic lab=VGND}
N 12640 -10 12660 -10 {lab=VGND}
C {devices/lab_pin.sym} 12660 -10 0 1 {name=l58 sig_type=std_logic lab=VGND}
N 13040 -10 13060 -10 {lab=VGND}
C {devices/lab_pin.sym} 13060 -10 0 1 {name=l59 sig_type=std_logic lab=VGND}
N 13440 -10 13460 -10 {lab=VGND}
C {devices/lab_pin.sym} 13460 -10 0 1 {name=l60 sig_type=std_logic lab=VGND}
N 13840 -10 13860 -10 {lab=VGND}
C {devices/lab_pin.sym} 13860 -10 0 1 {name=l61 sig_type=std_logic lab=VGND}
N 14240 -10 14260 -10 {lab=VGND}
C {devices/lab_pin.sym} 14260 -10 0 1 {name=l62 sig_type=std_logic lab=VGND}
N 14640 -10 14660 -10 {lab=VGND}
C {devices/lab_pin.sym} 14660 -10 0 1 {name=l63 sig_type=std_logic lab=VGND}
N 15040 -10 15060 -10 {lab=VGND}
C {devices/lab_pin.sym} 15060 -10 0 1 {name=l64 sig_type=std_logic lab=VGND}
N 6880 0 6860 0 {lab=D1_G}
N 6800 0 6860 0 {lab=D1_G}
N 7280 0 7260 0 {lab=D2_G}
N 7200 0 7260 0 {lab=D2_G}
N 8880 0 8860 0 {lab=D1_C}
N 8800 0 8860 0 {lab=D1_C}
N 9280 0 9260 0 {lab=D2_C}
N 9200 0 9260 0 {lab=D2_C}
N 10480 0 10460 0 {lab=OUT_A}
N 10400 0 10460 0 {lab=OUT_A}
N 10880 0 10860 0 {lab=OUT_B}
N 10800 0 10860 0 {lab=OUT_B}
N 11280 10 11260 10 {lab=CLR_MG}
N 11200 10 11260 10 {lab=CLR_MG}
N 11680 10 11660 10 {lab=CLR_MC}
N 11600 10 11660 10 {lab=CLR_MC}
N 14480 10 14460 10 {lab=CLR_N}
N 14460 10 14460 70 {lab=CLR_N}
N 14880 10 14860 10 {lab=CLR_N}
N 14860 10 14860 70 {lab=CLR_N}
N 14400 70 14460 70 {lab=CLR_N}
N 14460 70 14860 70 {lab=CLR_N}
N 2880 0 2860 0 {lab=OUT_G}
N 2860 0 2860 70 {lab=OUT_G}
N 3680 0 3660 0 {lab=OUT_G}
N 3660 0 3660 70 {lab=OUT_G}
N 2800 70 2860 70 {lab=OUT_G}
N 2860 70 3660 70 {lab=OUT_G}
N 4480 0 4460 0 {lab=OUT_C}
N 4460 0 4460 70 {lab=OUT_C}
N 5280 0 5260 0 {lab=OUT_C}
N 5260 0 5260 70 {lab=OUT_C}
N 4400 70 4460 70 {lab=OUT_C}
N 4460 70 5260 70 {lab=OUT_C}
N 9680 0 9660 0 {lab=VQUIET_A}
N 9660 0 9660 -70 {lab=VQUIET_A}
N 14480 -10 14460 -10 {lab=VQUIET_A}
N 14460 -10 14460 -70 {lab=VQUIET_A}
N 9600 -70 9660 -70 {lab=VQUIET_A}
N 9660 -70 14460 -70 {lab=VQUIET_A}
N 10080 0 10060 0 {lab=VQUIET_B}
N 10060 0 10060 -80 {lab=VQUIET_B}
N 14880 -10 14860 -10 {lab=VQUIET_B}
N 14860 -10 14860 -80 {lab=VQUIET_B}
N 10000 -80 10060 -80 {lab=VQUIET_B}
N 10060 -80 14860 -80 {lab=VQUIET_B}
N 7680 0 7660 0 {lab=VBIAS_C}
N 7660 0 7660 70 {lab=VBIAS_C}
N 13280 -10 13260 -10 {lab=VBIAS_C}
N 13260 -10 13260 70 {lab=VBIAS_C}
N 7600 70 7660 70 {lab=VBIAS_C}
N 7660 70 13260 70 {lab=VBIAS_C}
N 8080 0 8060 0 {lab=VINP_C}
N 8060 0 8060 80 {lab=VINP_C}
N 13680 -10 13660 -10 {lab=VINP_C}
N 13660 -10 13660 80 {lab=VINP_C}
N 8000 80 8060 80 {lab=VINP_C}
N 8060 80 13660 80 {lab=VINP_C}
N 8480 0 8460 0 {lab=VINM_C}
N 8460 0 8460 -90 {lab=VINM_C}
N 14080 -10 14060 -10 {lab=VINM_C}
N 14060 -10 14060 -90 {lab=VINM_C}
N 8400 -90 8460 -90 {lab=VINM_C}
N 8460 -90 14060 -90 {lab=VINM_C}
N 5680 0 5660 0 {lab=VBIAS_G}
N 5660 0 5660 90 {lab=VBIAS_G}
N 12080 -10 12060 -10 {lab=VBIAS_G}
N 12060 -10 12060 90 {lab=VBIAS_G}
N 5600 90 5660 90 {lab=VBIAS_G}
N 5660 90 12060 90 {lab=VBIAS_G}
N 6080 0 6060 0 {lab=VINP_G}
N 6060 0 6060 -100 {lab=VINP_G}
N 12480 -10 12460 -10 {lab=VINP_G}
N 12460 -10 12460 -100 {lab=VINP_G}
N 6000 -100 6060 -100 {lab=VINP_G}
N 6060 -100 12460 -100 {lab=VINP_G}
N 6480 0 6460 0 {lab=VINM_G}
N 6460 0 6460 100 {lab=VINM_G}
N 12880 -10 12860 -10 {lab=VINM_G}
N 12860 -10 12860 100 {lab=VINM_G}
N 6400 100 6460 100 {lab=VINM_G}
N 6460 100 12860 100 {lab=VINM_G}
N 12080 10 12040 10 {lab=CLR_PG}
C {devices/lab_pin.sym} 12040 10 0 0 {name=l84 sig_type=std_logic lab=CLR_PG}
N 12480 10 12460 10 {lab=CLR_PG}
C {devices/lab_pin.sym} 12460 10 0 0 {name=l85 sig_type=std_logic lab=CLR_PG}
N 12880 10 12840 10 {lab=CLR_PG}
C {devices/lab_pin.sym} 12840 10 0 0 {name=l86 sig_type=std_logic lab=CLR_PG}
N 13280 10 13240 10 {lab=CLR_PC}
C {devices/lab_pin.sym} 13240 10 0 0 {name=l87 sig_type=std_logic lab=CLR_PC}
N 13680 10 13640 10 {lab=CLR_PC}
C {devices/lab_pin.sym} 13640 10 0 0 {name=l88 sig_type=std_logic lab=CLR_PC}
N 14080 10 14060 10 {lab=CLR_PC}
C {devices/lab_pin.sym} 14060 10 0 0 {name=l89 sig_type=std_logic lab=CLR_PC}
N 4080 0 4060 0 {lab=REF_C}
C {devices/lab_pin.sym} 4060 0 0 0 {name=l90 sig_type=std_logic lab=REF_C}
N 4880 0 4860 0 {lab=REF_C}
C {devices/lab_pin.sym} 4860 0 0 0 {name=l91 sig_type=std_logic lab=REF_C}
N 11680 -10 11660 -10 {lab=REF_C}
C {devices/lab_pin.sym} 11660 -10 0 0 {name=l92 sig_type=std_logic lab=REF_C}
N 2480 0 2460 0 {lab=REF_G}
C {devices/lab_pin.sym} 2460 0 0 0 {name=l93 sig_type=std_logic lab=REF_G}
N 3280 0 3260 0 {lab=REF_G}
C {devices/lab_pin.sym} 3260 0 0 0 {name=l94 sig_type=std_logic lab=REF_G}
N 11280 -10 11260 -10 {lab=REF_G}
C {devices/lab_pin.sym} 11260 -10 0 0 {name=l95 sig_type=std_logic lab=REF_G}
N 6080 -20 6040 -20 {lab=UA1}
C {devices/lab_pin.sym} 6040 -20 0 0 {name=l96 sig_type=std_logic lab=UA1}
N 8080 -20 8060 -20 {lab=UA1}
C {devices/lab_pin.sym} 8060 -20 0 0 {name=l97 sig_type=std_logic lab=UA1}
N 9680 -20 9640 -20 {lab=UA1}
C {devices/lab_pin.sym} 9640 -20 0 0 {name=l98 sig_type=std_logic lab=UA1}
N 10080 -20 10040 -20 {lab=UA1}
C {devices/lab_pin.sym} 10040 -20 0 0 {name=l99 sig_type=std_logic lab=UA1}
N 2480 -20 2460 -20 {lab=UA0}
N 2460 -20 2460 -70 {lab=UA0}
N 4080 -20 4060 -20 {lab=UA0}
N 4060 -20 4060 -70 {lab=UA0}
N 5680 -20 5660 -20 {lab=UA0}
N 5660 -20 5660 -70 {lab=UA0}
N 7680 -20 7660 -20 {lab=UA0}
N 7660 -20 7660 -70 {lab=UA0}
N 2400 -70 2460 -70 {lab=UA0}
N 2460 -70 4060 -70 {lab=UA0}
N 4060 -70 5660 -70 {lab=UA0}
N 5660 -70 7660 -70 {lab=UA0}
N 2880 -20 2860 -20 {lab=UA2}
C {devices/lab_pin.sym} 2860 -20 0 0 {name=l101 sig_type=std_logic lab=UA2}
N 4480 -20 4460 -20 {lab=UA2}
C {devices/lab_pin.sym} 4460 -20 0 0 {name=l102 sig_type=std_logic lab=UA2}
N 6480 -20 6460 -20 {lab=UA2}
C {devices/lab_pin.sym} 6460 -20 0 0 {name=l103 sig_type=std_logic lab=UA2}
N 8480 -20 8440 -20 {lab=UA2}
C {devices/lab_pin.sym} 8440 -20 0 0 {name=l104 sig_type=std_logic lab=UA2}
N 480 -10 460 -10 {lab=EN_MG}
C {devices/lab_pin.sym} 460 -10 0 0 {name=l105 sig_type=std_logic lab=EN_MG}
N 2480 20 2460 20 {lab=EN_MG}
C {devices/lab_pin.sym} 2460 20 0 0 {name=l106 sig_type=std_logic lab=EN_MG}
N 2880 20 2840 20 {lab=EN_MG}
C {devices/lab_pin.sym} 2840 20 0 0 {name=l107 sig_type=std_logic lab=EN_MG}
N 3280 20 3260 20 {lab=EN_MG}
C {devices/lab_pin.sym} 3260 20 0 0 {name=l108 sig_type=std_logic lab=EN_MG}
N 3680 20 3640 20 {lab=EN_MG}
C {devices/lab_pin.sym} 3640 20 0 0 {name=l109 sig_type=std_logic lab=EN_MG}
N 480 10 440 10 {lab=ENB_MG}
N 440 10 440 80 {lab=ENB_MG}
N 2640 -20 2680 -20 {lab=ENB_MG}
N 2680 -20 2680 80 {lab=ENB_MG}
N 3040 -20 3080 -20 {lab=ENB_MG}
N 3080 -20 3080 80 {lab=ENB_MG}
N 3440 -20 3480 -20 {lab=ENB_MG}
N 3480 -20 3480 80 {lab=ENB_MG}
N 3840 -20 3880 -20 {lab=ENB_MG}
N 3880 -20 3880 80 {lab=ENB_MG}
N 440 80 2680 80 {lab=ENB_MG}
N 2680 80 3080 80 {lab=ENB_MG}
N 3080 80 3480 80 {lab=ENB_MG}
N 3480 80 3880 80 {lab=ENB_MG}
C {devices/lab_pin.sym} 440 80 0 0 {name=l110 sig_type=std_logic lab=ENB_MG}
N 880 -10 860 -10 {lab=EN_MC}
C {devices/lab_pin.sym} 860 -10 0 0 {name=l111 sig_type=std_logic lab=EN_MC}
N 4080 20 4060 20 {lab=EN_MC}
C {devices/lab_pin.sym} 4060 20 0 0 {name=l112 sig_type=std_logic lab=EN_MC}
N 4480 20 4440 20 {lab=EN_MC}
C {devices/lab_pin.sym} 4440 20 0 0 {name=l113 sig_type=std_logic lab=EN_MC}
N 4880 20 4860 20 {lab=EN_MC}
C {devices/lab_pin.sym} 4860 20 0 0 {name=l114 sig_type=std_logic lab=EN_MC}
N 5280 20 5240 20 {lab=EN_MC}
C {devices/lab_pin.sym} 5240 20 0 0 {name=l115 sig_type=std_logic lab=EN_MC}
N 880 10 840 10 {lab=ENB_MC}
N 840 10 840 90 {lab=ENB_MC}
N 4240 -20 4280 -20 {lab=ENB_MC}
N 4280 -20 4280 90 {lab=ENB_MC}
N 4640 -20 4680 -20 {lab=ENB_MC}
N 4680 -20 4680 90 {lab=ENB_MC}
N 5040 -20 5080 -20 {lab=ENB_MC}
N 5080 -20 5080 90 {lab=ENB_MC}
N 5440 -20 5480 -20 {lab=ENB_MC}
N 5480 -20 5480 90 {lab=ENB_MC}
N 840 90 4280 90 {lab=ENB_MC}
N 4280 90 4680 90 {lab=ENB_MC}
N 4680 90 5080 90 {lab=ENB_MC}
N 5080 90 5480 90 {lab=ENB_MC}
C {devices/lab_pin.sym} 840 90 0 0 {name=l116 sig_type=std_logic lab=ENB_MC}
N 3280 -20 3260 -20 {lab=UA3}
C {devices/lab_pin.sym} 3260 -20 0 0 {name=l117 sig_type=std_logic lab=UA3}
N 4880 -20 4860 -20 {lab=UA3}
C {devices/lab_pin.sym} 4860 -20 0 0 {name=l118 sig_type=std_logic lab=UA3}
N 6880 -20 6860 -20 {lab=UA3}
C {devices/lab_pin.sym} 6860 -20 0 0 {name=l119 sig_type=std_logic lab=UA3}
N 8880 -20 8860 -20 {lab=UA3}
C {devices/lab_pin.sym} 8860 -20 0 0 {name=l120 sig_type=std_logic lab=UA3}
N 10480 -20 10460 -20 {lab=UA3}
C {devices/lab_pin.sym} 10460 -20 0 0 {name=l121 sig_type=std_logic lab=UA3}
N 3680 -20 3660 -20 {lab=UA4}
C {devices/lab_pin.sym} 3660 -20 0 0 {name=l122 sig_type=std_logic lab=UA4}
N 5280 -20 5260 -20 {lab=UA4}
C {devices/lab_pin.sym} 5260 -20 0 0 {name=l123 sig_type=std_logic lab=UA4}
N 7280 -20 7260 -20 {lab=UA4}
C {devices/lab_pin.sym} 7260 -20 0 0 {name=l124 sig_type=std_logic lab=UA4}
N 9280 -20 9260 -20 {lab=UA4}
C {devices/lab_pin.sym} 9260 -20 0 0 {name=l125 sig_type=std_logic lab=UA4}
N 10880 -20 10860 -20 {lab=UA4}
C {devices/lab_pin.sym} 10860 -20 0 0 {name=l126 sig_type=std_logic lab=UA4}
N 2080 -10 2060 -10 {lab=EN_N}
C {devices/lab_pin.sym} 2060 -10 0 0 {name=l127 sig_type=std_logic lab=EN_N}
N 9680 20 9660 20 {lab=EN_N}
C {devices/lab_pin.sym} 9660 20 0 0 {name=l128 sig_type=std_logic lab=EN_N}
N 10080 20 10060 20 {lab=EN_N}
C {devices/lab_pin.sym} 10060 20 0 0 {name=l129 sig_type=std_logic lab=EN_N}
N 10480 20 10460 20 {lab=EN_N}
C {devices/lab_pin.sym} 10460 20 0 0 {name=l130 sig_type=std_logic lab=EN_N}
N 10880 20 10860 20 {lab=EN_N}
C {devices/lab_pin.sym} 10860 20 0 0 {name=l131 sig_type=std_logic lab=EN_N}
N 2080 10 2060 10 {lab=ENB_N}
C {devices/lab_pin.sym} 2060 10 0 0 {name=l132 sig_type=std_logic lab=ENB_N}
N 9840 -20 9860 -20 {lab=ENB_N}
C {devices/lab_pin.sym} 9860 -20 0 1 {name=l133 sig_type=std_logic lab=ENB_N}
N 10240 -20 10260 -20 {lab=ENB_N}
C {devices/lab_pin.sym} 10260 -20 0 1 {name=l134 sig_type=std_logic lab=ENB_N}
N 10640 -20 10660 -20 {lab=ENB_N}
C {devices/lab_pin.sym} 10660 -20 0 1 {name=l135 sig_type=std_logic lab=ENB_N}
N 11040 -20 11060 -20 {lab=ENB_N}
C {devices/lab_pin.sym} 11060 -20 0 1 {name=l136 sig_type=std_logic lab=ENB_N}
N 1280 -10 1260 -10 {lab=EN_PG}
C {devices/lab_pin.sym} 1260 -10 0 0 {name=l137 sig_type=std_logic lab=EN_PG}
N 5680 20 5640 20 {lab=EN_PG}
C {devices/lab_pin.sym} 5640 20 0 0 {name=l138 sig_type=std_logic lab=EN_PG}
N 6080 20 6060 20 {lab=EN_PG}
C {devices/lab_pin.sym} 6060 20 0 0 {name=l139 sig_type=std_logic lab=EN_PG}
N 6480 20 6440 20 {lab=EN_PG}
C {devices/lab_pin.sym} 6440 20 0 0 {name=l140 sig_type=std_logic lab=EN_PG}
N 6880 20 6860 20 {lab=EN_PG}
C {devices/lab_pin.sym} 6860 20 0 0 {name=l141 sig_type=std_logic lab=EN_PG}
N 7280 20 7260 20 {lab=EN_PG}
C {devices/lab_pin.sym} 7260 20 0 0 {name=l142 sig_type=std_logic lab=EN_PG}
N 1280 10 1260 10 {lab=ENB_PG}
C {devices/lab_pin.sym} 1260 10 0 0 {name=l143 sig_type=std_logic lab=ENB_PG}
N 5840 -20 5860 -20 {lab=ENB_PG}
C {devices/lab_pin.sym} 5860 -20 0 1 {name=l144 sig_type=std_logic lab=ENB_PG}
N 6240 -20 6260 -20 {lab=ENB_PG}
C {devices/lab_pin.sym} 6260 -20 0 1 {name=l145 sig_type=std_logic lab=ENB_PG}
N 6640 -20 6660 -20 {lab=ENB_PG}
C {devices/lab_pin.sym} 6660 -20 0 1 {name=l146 sig_type=std_logic lab=ENB_PG}
N 7040 -20 7060 -20 {lab=ENB_PG}
C {devices/lab_pin.sym} 7060 -20 0 1 {name=l147 sig_type=std_logic lab=ENB_PG}
N 7440 -20 7460 -20 {lab=ENB_PG}
C {devices/lab_pin.sym} 7460 -20 0 1 {name=l148 sig_type=std_logic lab=ENB_PG}
N 1680 -10 1660 -10 {lab=EN_PC}
C {devices/lab_pin.sym} 1660 -10 0 0 {name=l149 sig_type=std_logic lab=EN_PC}
N 7680 20 7640 20 {lab=EN_PC}
C {devices/lab_pin.sym} 7640 20 0 0 {name=l150 sig_type=std_logic lab=EN_PC}
N 8080 20 8040 20 {lab=EN_PC}
C {devices/lab_pin.sym} 8040 20 0 0 {name=l151 sig_type=std_logic lab=EN_PC}
N 8480 20 8460 20 {lab=EN_PC}
C {devices/lab_pin.sym} 8460 20 0 0 {name=l152 sig_type=std_logic lab=EN_PC}
N 8880 20 8860 20 {lab=EN_PC}
C {devices/lab_pin.sym} 8860 20 0 0 {name=l153 sig_type=std_logic lab=EN_PC}
N 9280 20 9260 20 {lab=EN_PC}
C {devices/lab_pin.sym} 9260 20 0 0 {name=l154 sig_type=std_logic lab=EN_PC}
N 1680 10 1640 10 {lab=ENB_PC}
N 1640 10 1640 -80 {lab=ENB_PC}
N 7840 -20 7880 -20 {lab=ENB_PC}
N 7880 -20 7880 -80 {lab=ENB_PC}
N 8240 -20 8280 -20 {lab=ENB_PC}
N 8280 -20 8280 -80 {lab=ENB_PC}
N 8640 -20 8680 -20 {lab=ENB_PC}
N 8680 -20 8680 -80 {lab=ENB_PC}
N 9040 -20 9080 -20 {lab=ENB_PC}
N 9080 -20 9080 -80 {lab=ENB_PC}
N 9440 -20 9480 -20 {lab=ENB_PC}
N 9480 -20 9480 -80 {lab=ENB_PC}
N 1640 -80 7880 -80 {lab=ENB_PC}
N 7880 -80 8280 -80 {lab=ENB_PC}
N 8280 -80 8680 -80 {lab=ENB_PC}
N 8680 -80 9080 -80 {lab=ENB_PC}
N 9080 -80 9480 -80 {lab=ENB_PC}
C {devices/lab_pin.sym} 1640 -80 0 0 {name=l155 sig_type=std_logic lab=ENB_PC}
C {devices/iopin.sym} 2400 -70 0 1 {name=p100 lab=UA0}
C {devices/iopin.sym} -160 140 0 1 {name=p162 lab=UA1}
C {devices/iopin.sym} -160 180 0 1 {name=p163 lab=UA2}
C {devices/iopin.sym} -160 300 0 1 {name=p166 lab=UA3}
C {devices/iopin.sym} -160 340 0 1 {name=p167 lab=UA4}
C {devices/iopin.sym} -160 100 0 1 {name=p161 lab=REF_G}
C {devices/iopin.sym} 2800 70 0 1 {name=p74 lab=OUT_G}
C {devices/iopin.sym} -160 60 0 1 {name=p160 lab=REF_C}
C {devices/iopin.sym} 4400 70 0 1 {name=p75 lab=OUT_C}
C {devices/iopin.sym} 5600 90 0 1 {name=p81 lab=VBIAS_G}
C {devices/iopin.sym} 6000 -100 0 1 {name=p82 lab=VINP_G}
C {devices/iopin.sym} 6400 100 0 1 {name=p83 lab=VINM_G}
C {devices/iopin.sym} 6800 0 0 1 {name=p65 lab=D1_G}
C {devices/iopin.sym} 7200 0 0 1 {name=p66 lab=D2_G}
C {devices/iopin.sym} 7600 70 0 1 {name=p78 lab=VBIAS_C}
C {devices/iopin.sym} 8000 80 0 1 {name=p79 lab=VINP_C}
C {devices/iopin.sym} 8400 -90 0 1 {name=p80 lab=VINM_C}
C {devices/iopin.sym} 8800 0 0 1 {name=p67 lab=D1_C}
C {devices/iopin.sym} 9200 0 0 1 {name=p68 lab=D2_C}
C {devices/iopin.sym} 9600 -70 0 1 {name=p76 lab=VQUIET_A}
C {devices/iopin.sym} 10000 -80 0 1 {name=p77 lab=VQUIET_B}
C {devices/iopin.sym} 10400 0 0 1 {name=p69 lab=OUT_A}
C {devices/iopin.sym} 10800 0 0 1 {name=p70 lab=OUT_B}
C {devices/iopin.sym} -160 220 0 1 {name=p164 lab=EN_MG}
C {devices/iopin.sym} -160 260 0 1 {name=p165 lab=EN_MC}
C {devices/iopin.sym} -160 420 0 1 {name=p169 lab=EN_PG}
C {devices/iopin.sym} -160 460 0 1 {name=p170 lab=EN_PC}
C {devices/iopin.sym} -160 380 0 1 {name=p168 lab=EN_N}
C {devices/iopin.sym} 11200 10 0 1 {name=p71 lab=CLR_MG}
C {devices/iopin.sym} 11600 10 0 1 {name=p72 lab=CLR_MC}
C {devices/iopin.sym} -160 -20 0 1 {name=p158 lab=CLR_PG}
C {devices/iopin.sym} -160 20 0 1 {name=p159 lab=CLR_PC}
C {devices/iopin.sym} 14400 70 0 1 {name=p73 lab=CLR_N}
C {devices/iopin.sym} -160 -100 0 1 {name=p156 lab=VDPWR}
C {devices/iopin.sym} -160 -60 0 1 {name=p157 lab=VGND}
